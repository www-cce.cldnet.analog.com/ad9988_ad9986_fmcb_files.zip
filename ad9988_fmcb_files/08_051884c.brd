# Allegro board 08_051884c.brd (continued)
## Text on the board (continued)
User.20: L5 POWER ANALOG | 08-      -10
User.22: L6 GROUND | 08-      -11
User.23: L7 POWER DIGITAL | 08-      -12
User.24: L8 GROUND | 08-      -13
User.25: L9 POWER DVDD1 | 08-      -14
User.26: L10 SIGNAL | 08-      -15
User.27: L11 GROUND | 08-      -16
User.33: LAYER 12 TO LAYER 9 DRILLS | LAYER 1 TO LAYER 4 DRILLS | SEE NOTE 15
User.45: FIGURE | SIZE | 8.0 | 6.0 | 10.0 | 12.0 | 16.0 | 20.0 | 40.0 | 50.0 | 75.0 | 105.0 | DRILL CHART: TOP to L4_GROUND | FINISHED HOLES IN MILS | PLATED | DRILL CHART: TOP to BOTTOM | NON-PLATED | DRILL CHART: L9_POWER_DVDD1 to BOTTOM | QTY | 1109 | 4 | 867 | 292 | 162 | 72 | 3 | 2 | 837 | TOLERANCE/NOTES
