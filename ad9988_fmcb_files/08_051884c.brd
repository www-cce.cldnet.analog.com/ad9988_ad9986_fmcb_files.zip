# Allegro board 08_051884c.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SYSREF_N: length 45.5
  TOP w0.102: C4C.1 R1C.2 v3(141.86,125.34)
  L10_SIGNAL w0.133: v1(153.81,163.95) 153.79,163.95 153.42,163.58 153.42,162.26 153.66,162.01 153.66,161.36 142.62,150.32 142.62,147.83 141.48,146.69 141.48,143.21 142.11,142.57 142.11,125.59 v3(141.86,125.34)
SYSREF_P: length 45.5
  TOP w0.102: v3(142.75,125.34) R1C.1 C1C.2
  L10_SIGNAL w0.133: v3(142.75,125.34) 142.37,125.71 142.37,142.68 141.74,143.32 141.74,146.58 142.88,147.73 142.88,150.21 153.92,161.25 153.92,162.05 154.18,162.3 154.18,163.45 154.61,163.88 v1(154.61,163.95)
TXEN0: length 38.3
  TOP w0.241: U3FF.3 166.97,133.21 166.49,133.68 165.48,133.68 v6(163.95,135.21)
  L3_SIGNAL w0.178: v1(161.81,165.55) 162.26,165.1 163.5,165.1 163.72,164.88 163.72,162 163.52,161.8 163.52,159.01 164.72,157.81 164.72,154.89 164.27,154.45 164.27,153.68 163.62,153.04 163.62,150.88 162.35,149.61 162.35,144.17 162.58,143.95 162.58,143.22 162.71,143.09 162.71,141.78 163.45,141.04 163.45,135.71 v6(163.95,135.21)
TXEN1: length 38.3
  TOP w0.241: v6(163.19,135.33) 163.5,135.02 163.5,135.02 163.77,134.76 163.77,134.76 165.48,133.05 166.37,133.05 166.7,132.71 U3FF.4
  L3_SIGNAL w0.178: v6(163.19,135.33) 163,135.14 162.75,135.14 162.31,135.58 162.31,143.03 162.25,143.08 162.25,143.51 161.73,144.03 161.73,149.6 163.24,151.11 163.24,153.16 163.94,153.86 163.94,155.03 164.34,155.42 164.34,157.56 163.19,158.7 163.19,161.88 163.07,162.01 163.07,164.08 162.81,164.34 162.22,164.34 v1(161.81,164.75)
UNNAMED_5_CAP_I7_N1: length 31.3
  TOP w0.279: C2Z.1 127.61,140.9 arc(128.98,141.2) 130.09,142.06 131.7,144.02 arc(138.82,152.12) T1Z.3 arc(147.32,160.03) T10.1
UNNAMED_5_CAP_I15_N1: length 31.3
  TOP w0.279: T9.1 arc(147.63,178.6) T1W.3 arc(145.85,180.99) 144.38,182.57 134.25,193.55 arc(130.04,196.41) C2W.1
UNNAMED_5_CAP_I22_N1: length 26.3
  BOTTOM w0.279: C2Y.1 135.96,155.78 arc(136.9,155.93) 137.74,156.36 145.38,161.8 T1Y.3 arc(147.61,163.81) T6.1
UNNAMED_5_CAP_I22_N2: length 3.5
  BOTTOM w0.279: DAC2.1 C2Y.2
UNNAMED_5_CAP_I29_N1: length 25.6
  BOTTOM w0.279: T3.1 147.87,174.22 147.77,174.2 147.69,174.2 147.49,174.17 147,174.17 146.39,174.22 T1X.3 143.88,175.82 141.5,177.5 arc(136.52,180.68) 131.08,182.99 arc(130.95,183.03) 130.81,183.07 128.26,183.69 arc(128.12,183.72) 127.98,183.75 arc(126.5,183.95) C2X.1
UNNAMED_5_CAP_I29_N2: length 3.6
  BOTTOM w0.279: DAC1.1 C2X.2
UNNAMED_5_CAP_I45_N2: length 1.5
  BOTTOM w0.254: C1S.2 155.19,178.22 T1S.4
UNNAMED_5_CAP_I46_N2: length 1.5
  BOTTOM w0.254: T1S.5 156.46,178.22 C2S.2
UNNAMED_5_CAP_I50_N1: length 48.6
  BOTTOM w0.279: C3S.1 125.8,210.9 126.36,210.9 127.12,210.91 arc(130.33,210.3) 133.06,208.5 136.59,204.96 arc(140.65,202.25) 145.44,201.3 146.2,201.3 arc(146.34,201.29) 146.48,201.28 146.86,201.24 arc(152.48,198.44) 155.14,192.75 arc(155.18,192.28) 155.19,191.81 155.19,188.36 155.19,188.35 T1S.3 arc(155.59,182.12) T12.1
UNNAMED_5_CAP_I56_N1: length 49.1
  BOTTOM w0.279: T8.1 156.14,155.83 arc(156.36,155.5) T1T.3 156.45,155.1 156.45,154.13 156.53,151.72 156.53,147.4 arc(156.04,144.96) 154.66,142.89 154.07,142.31 152.97,141.58 arc(151.91,141.09) 150.76,140.92 143.86,140.92 arc(140.19,140.19) 137.07,138.11 126.88,127.91 arc(126.39,127.54) C3T.1
UNNAMED_5_CAP_I59_N2: length 1.5
  BOTTOM w0.254: C2T.2 155.17,158.63 155.17,158.62 T1T.5
UNNAMED_5_CAP_I60_N2: length 1.5
  BOTTOM w0.254: C1T.2 156.44,158.63 156.44,158.62 T1T.4
UNNAMED_5_CAP_I64_N1: length 63.8
  TOP w0.279: T7.1 159.34,183.14 arc(159.56,183.48) T1U.3 159.7,186.73 159.7,190.96 159.67,191.79 arc(158.49,196.63) 155.45,200.59 154.38,201.51 arc(152.38,202.7) 150.1,203.18 148.08,203.26 arc(148.04,203.26) 147.99,203.26 141.45,203.28 arc(139.13,203.74) 137.16,205.06 131.89,210.33 arc(130.52,212.37) 130.05,214.77 130.05,220.59 arc(130.04,220.72) 130.02,220.85 arc(128.58,223.39) 125.83,224.4 C3U.1
UNNAMED_5_CAP_I67_N2: length 2.3
  TOP w0.254: T1U.5 C2U.2
UNNAMED_5_CAP_I68_N2: length 2.3
  TOP w0.254: T1U.4 C1U.2
UNNAMED_5_CAP_I72_N1: length 60.4
  TOP w0.279: C3V.1 127.12,115.33 arc(128.91,118) 129.54,121.16 arc(130.59,126.44) 133.58,130.91 135.29,132.62 arc(141.16,136.54) 148.08,137.92 arc(152.17,138.73) 155.63,141.05 157.22,142.64 arc(157.93,143.7) 158.18,144.94 158.18,151.61 T1V.3 arc(158.77,155.28) T11.1
UNNAMED_5_CAP_I75_N2: length 2.3
  TOP w0.254: T1V.5 159.64,159.93 C2V.2
UNNAMED_5_CAP_I76_N2: length 2.3
  TOP w0.254: T1V.4 158.37,157.65 C1V.2
UNNAMED_6_ADHMC7044_I49_BGABYP1: length 2.9
  BOTTOM w0.241: C1B.1 139.78,110.98 140.43,111.63 U1B.7
UNNAMED_6_ADHMC7044_I49_CLKIN0: length 3.2
  BOTTOM w0.241: U1B.39 154.05,114.63 154.43,114.25 155.1,114.25 C11B.2
UNNAMED_6_ADHMC7044_I49_CLKIN0N: length 3.5
  BOTTOM w0.241: U1B.40 152.87,114.13 153.9,113.11 154.08,113.11 154.09,113.1 154.44,113.1 154.44,113.11 154.97,113.11 C12B.2
UNNAMED_6_ADHMC7044_I49_CLKOUT0: length 3.8
  BOTTOM w0.102: C29B.1 139.81,107.42 140.49,107.42 141.09,108.03 141.09,108.52 141.35,108.77 141.49,108.77 141.62,108.63 U1B.1
UNNAMED_6_ADHMC7044_I49_CLKOUT0N: length 3.9
  BOTTOM w0.102: C30B.1 139.86,107.65 140.39,107.65 140.87,108.12 140.87,108.61 141.25,109 141.49,109 141.62,109.13 U1B.2
UNNAMED_6_ADHMC7044_I49_CLKOUT6_1: length 1.7
  BOTTOM w0.102: C31B.1 147.88,118.8 147.88,118.01 147.75,117.88 U1B.27
UNNAMED_6_ADHMC7044_I49_CLKOUT6N: length 1.7
  BOTTOM w0.102: U1B.28 148.25,117.87 148.11,118.01 148.11,118.76 C32B.1
UNNAMED_6_ADHMC7044_I49_CLKOUT8_1: length 2.2
  BOTTOM w0.102: C33B.1 150.16,106.23 150.16,106.52 149.65,107.03 149.65,107.18 149.75,107.27 U1B.55
UNNAMED_6_ADHMC7044_I49_CLKOUT8N: length 2.2
  BOTTOM w0.102: U1B.56 149.25,107.31 149.38,107.19 149.38,106.98 149.94,106.43 149.94,106.24 C34B.1
UNNAMED_6_ADHMC7044_I49_CLKOUT10: length 2.1
  BOTTOM w0.102: U1B.58 148.25,107.41 148.08,107.24 148.08,106.94 147.68,106.53 147.68,106.18 C35B.1
UNNAMED_6_ADHMC7044_I49_CLKOUT10N: length 2.2
  BOTTOM w0.102: C36B.1 147.45,106.29 147.45,106.63 147.85,107.04 147.85,107.24 147.75,107.34 U1B.59
UNNAMED_6_ADHMC7044_I49_CLKOUT12: length 2
  BOTTOM w0.102: C37B.1 143.97,106.2 143.97,106.82 144.11,106.96 144.11,107.21 144.25,107.36 U1B.66
UNNAMED_6_ADHMC7044_I49_CLKOUT12N: length 2
  BOTTOM w0.102: C38B.1 143.74,106.26 143.74,106.92 143.88,107.05 143.88,107.19 143.75,107.31 U1B.67
UNNAMED_6_ADHMC7044_I49_CPOUT2: length 5.6
  BOTTOM w0.241: C41B.1 154.6,106.15 C42B.1 153.92,106.6 153.92,108.16 152.94,109.13 U1B.50
UNNAMED_6_ADHMC7044_I49_GPIO2: length 1.7
  BOTTOM w0.241: U1B.52 151.25,106.21 R2B.1
UNNAMED_6_ADHMC7044_I49_LDOBYP2: length 2.7
  BOTTOM w0.241: U1B.8 139.88,112.13 C2B.1
UNNAMED_6_ADHMC7044_I49_LDOBYP3: length 2.8
  BOTTOM w0.241: C5B.1 140.13,112.63 U1B.9
UNNAMED_6_ADHMC7044_I49_LDOBYP4: length 4.7
  BOTTOM w0.127: C17B.2 138.77,116.06 139.4,115.43
  BOTTOM w0.241: 139.4,115.43 139.75,115.09 C8B.1 139.78,115.05 140.34,114.48 140.34,114.38 141.08,113.63 U1B.11
UNNAMED_6_ADHMC7044_I49_LDOBYP5: length 3.7
  BOTTOM w0.241: U1B.12 141.28,114.13 140.34,115.08 140.34,115.5 139.78,116.06 C17B.1
UNNAMED_6_ADHMC7044_I49_LDOBYP6: length 3.1
  BOTTOM w0.241: U1B.46 154.98,111.13 C18B.1
UNNAMED_6_ADHMC7044_I49_LDOBYP7: length 4.1
  BOTTOM w0.241: C19B.1 154.38,108.31 154.38,108.59 153.33,109.63 U1B.49
UNNAMED_6_ADHMC7044_I49_OSCIN: length 3.4
  BOTTOM w0.241: C15B.2 154.34,110.63 U1B.47
UNNAMED_6_ADHMC7044_I49_OSCINN: length 3.6
  BOTTOM w0.241: U1B.48 153.7,110.13 C16B.2
UNNAMED_6_ADHMC7044_I49_RESET: length 3.3
  BOTTOM w0.241: R4B.1 140.22,108.95 141.9,110.63 U1B.5
UNNAMED_6_ADHMC7044_I49_SCLKOUT13: length 2.1
  BOTTOM w0.102: C39B.1 145.41,106.28 145.41,106.65 145.12,106.94 145.12,107.23 145.25,107.36 U1B.64
UNNAMED_6_ADHMC7044_I49_SCLKOUT13N: length 2.1
  BOTTOM w0.102: U1B.65 144.75,107.43 144.9,107.29 144.9,106.84 145.19,106.55 145.19,106.19 C40B.1
UNNAMED_6_CAP_I18_N1: length 15.5
  L10_SIGNAL w0.254: v2(156.59,109.84) 159.64,112.89 159.64,115.01 159.13,115.52 157.86,115.52 157.22,114.89 154.56,114.89 v2(153.67,115.77)
  BOTTOM w0.241: R1B.2 v2(156.59,109.84) C15B.1
  BOTTOM w0.254: R25.2 154.1,116.21 v2(153.67,115.77)
UNNAMED_6_CAP_I19_N1: length 9.2
  BOTTOM w0.241: Y2B.4 159.46,120.09 154.85,120.09 C10B.1 C4B.1 C7B.1 153.99,123.24 E2B.2
UNNAMED_6_CAP_I27_N2: length 1
  BOTTOM w0.254: C13B.2 155.12,117.85 R25.1
UNNAMED_6_CAP_I36_N1: length 7.5
  BOTTOM w0.241: C12B.1 157.13,113.27 157.6,113.74 160.53,113.74 161.62,114.84 161.62,115.5 Y1B.5
UNNAMED_6_CAP_I37_N1: length 4.2
  BOTTOM w0.241: C11B.1 156.17,114.38 156.84,114.38 158.45,115.99 Y1B.4
UNNAMED_6_CAP_I97_N2: length 1.2
  BOTTOM w0.241: C42B.2 153.47,104.13 R5B.1
UNNAMED_6_CAP_I109_N2: length 1
  BOTTOM w0.241: R6B.1 151.81,120.13 C44B.2
UNNAMED_6_CAP_I146_N1: length 56.9
  TOP w0.279: C3D.1 v6(148.45,170.38)
  L3_SIGNAL w0.133: v6(148.45,170.38) 148.45,169.53 arc(148.36,169.32) 148.14,169.25 arc(148.11,169.25) 148.08,169.25 147.44,169.25 arc(146.9,169.02) 146.68,168.48 146.68,167.72 arc(146.6,167.54) 146.43,167.47 143.33,167.47 arc(142.91,167.3) 142.74,166.88 142.74,153.3 arc(142.96,152.21) 143.58,151.28 arc(143.9,150.8) 144.01,150.24 144.01,145.63 arc(143.3,142.08) 141.29,139.07 arc(140.95,138.57) 140.83,137.97 140.83,126.53 arc(140.84,126.47) 140.87,126.43 140.88,126.42 arc(140.95,126.33) 140.97,126.21 140.97,121.54 arc(140.89,121.14) 140.66,120.8 v3(140.59,120.73)
  BOTTOM w0.279: v3(140.59,120.73) 140.59,120.72 L2D.2
UNNAMED_6_CAP_I147_N2: length 1.7
  TOP w0.254: T1D.4 146.46,169.88 146.53,169.8 C4D.2
UNNAMED_6_CAP_I152_N1: length 56.4
  TOP w0.279: C5D.1 v6(148.47,167.96)
  L3_SIGNAL w0.133: v6(148.47,167.96) 148.47,168.6 arc(148.36,168.87) 148.08,168.99 147.44,168.99 arc(147.09,168.84) 146.94,168.48 146.94,167.72 arc(146.79,167.36) 146.43,167.21 143.33,167.21 arc(143.1,167.11) 143,166.88 143,153.3 arc(143.2,152.31) 143.76,151.46 arc(144.14,150.9) 144.27,150.24 144.27,145.63 arc(143.54,141.98) 141.48,138.89 arc(141.19,138.47) 141.09,137.97 141.09,126.66 arc(141.11,126.58) 141.16,126.5 arc(141.21,126.43) 141.23,126.34 141.23,121.54 arc(141.31,121.13) 141.55,120.78 v3(141.6,120.73)
  BOTTOM w0.279: L1D.2 141.6,120.72 v3(141.6,120.73)
UNNAMED_6_CAP_I154_N2: length 1.7
  TOP w0.254: C6D.2 146.53,168.53 146.45,168.45 T1D.6
UNNAMED_6_CAP_I157_N2: length 1.8
  TOP w0.241: T1R.4 C2R.2
UNNAMED_6_CAP_I160_N2: length 1.8
  TOP w0.241: C1R.2 T1R.5
UNNAMED_6_CAP_I162_N1: length 1.7
  TOP w0.279: C3R.1 T1R.3
UNNAMED_6_RES_I14_N1: length 15.6
  L10_SIGNAL w0.178: v5(165.86,120.09) 165.48,119.71 164.02,119.71 162.3,117.99 162.3,116.31 160.2,114.2 160.2,112.47 v2(158.16,110.44)
  BOTTOM w0.241: Y2B.3 165.85,120.08 v5(165.86,120.09) ; R1B.1 v2(158.16,110.44)
UNNAMED_8_AD71758_I49_AVDD1: length 7.2
  BOTTOM w0.254: C12.1 144.72,211.56 ; 144.72,211.56 144.71,211.56 C7.1 144.71,213.69 ; 144.72,211.56 U3.A2 U3.B2 ; U1.9 144.81,213.78 144.71,213.69 ; 144.71,213.69 144.6,213.69 144.31,213.98 ; 144.31,213.98 U1.10 ; 144.31,213.98 143.89,213.56 143.89,213.25 C8.1
UNNAMED_8_AD71758_I49_DOUT: length 1.3
  BOTTOM w0.254: R3.1 142.64,216.65 142.67,216.62 143.09,216.62 143.1,216.62 U1.14
UNNAMED_8_AD71758_I49_REF: length 1.3
  BOTTOM w0.254: U1.39 150.71,215.62 C4.1
UNNAMED_8_AD71758_I49_REGCAPA: length 2.6
  BOTTOM w0.254: C1.1 146.24,212.22 C5.1 146.17,213.12 146.17,213.56 145.81,213.93 U1.7
UNNAMED_8_AD71758_I49_REGCAPD: length 2.4
  BOTTOM w0.241: C2.1 145.03,222.57 145.03,222.07 144.84,221.88 C6.1 144.81,221.66 U1.22
UNNAMED_8_ADP7112_I50_SS: length 1.7
  BOTTOM w0.254: C14.1 142.62,210.55 U3.B1
UNNAMED_10_ICFXL4TD245_I9_OEN: length 2.7
  TOP w0.241: R6FF.1 R7FF.1 168.52,129.85 168.91,130.23 U3FF.9
UNNAMED_10_ICFXL4TD245_I32_A3: length 1.4
  TOP w0.241: U2FF.6 165.99,139.97 R8FF.1
UNNAMED_10_ICFXL4TD245_I32_OEN: length 5.3
  TOP w0.241: R5FF.1 R4FF.1 166.11,137.49 168.4,137.49 168.91,138 U2FF.9
UNNAMED_10_ICFXL4TD245_I36_A2: length 4.6
  TOP w0.241: R12.1 164.84,147.78 ; 164.84,147.78 164.59,147.78 163.57,148.79 163.57,148.79 R6.1 ; 164.84,147.78 165.1,147.78 165.48,148.16 166.39,148.16 166.46,148.09 U1FF.5
UNNAMED_10_ICFXL4TD245_I36_A3: length 8.8
  TOP w0.241: U1FF.6 166.68,147.59 166.24,147.14 164.21,147.14 163.57,147.78 162.43,147.78 ; 162.43,147.78 R13.1 ; 162.43,147.78 161.8,147.14 161.02,147.14 160.78,147.39 R7.1
UNNAMED_10_ICFXL4TD245_I36_OEN: length 5.2
  TOP w0.241: R2FF.1 R3FF.1 166.53,145.57 168.73,145.57 168.91,145.74 U1FF.9
UNNAMED_10_ICFXL4TD245_I68_OEN: length 2.7
  TOP w0.241: R15FF.1 R14FF.1 168.91,121.29 U5FF.9
UNNAMED_10_ICFXL4TD245_I72_OEN: length 2.7
  TOP w0.241: R13FF.1 R12FF.1 162.17,121.03 162.56,121.41 U4FF.9
UNNAMED_10_ICNLSX5014_I91_EN: length 3
  TOP w0.241: R21FF.1 R20FF.1 168.71,113.58 168.71,113.92 169.54,114.76 U8FF.12
UNNAMED_10_ICNLSX5014_I104_EN: length 3
  TOP w0.127: U7FF.12 161.29,114.76 160.91,114.38
  TOP w0.241: R19FF.1 R18FF.1 160.28,113.75 160.91,114.38
UNNAMED_10_ICNLSX5014_I107_EN: length 3
  TOP w0.203: 153.67,114.51 U6FF.12
  TOP w0.241: 153.67,114.51 152.66,113.5 R16FF.1 R17FF.1
UNNAMED_10_ICNLSX5014_I128_EN: length 2.8
  TOP w0.241: U10FF.12 146.81,102.17 146.31,101.67 R33FF.1 146.16,101.45 R34FF.1
UNNAMED_12_AD9986V2_I180_DNC1:
  vias: v1(157.01,175.15)
UNNAMED_12_AD9986V2_I180_DNC6:
  vias: v1(157.01,163.15)
UNNAMED_12_AD9986V2_I180_ISET: length 0.2
  BOTTOM w0.279: R2AA.1 v1(153.81,170.35)
UNNAMED_12_AD9986V2_I180_SDO: length 33.2
  TOP w0.241: R11.1 164.59,150.97 164.35,151.21 163.83,151.21 163.07,151.97 163.07,152.1 162.92,152.24 162.92,156.19 163.02,156.28 163.02,156.81 163.26,157.05 164.84,157.05 165.32,157.53 165.32,159.49 164.59,160.23 164.59,160.86 165.48,161.75 166.62,161.75 167.38,160.99 167.38,160.35 166.88,159.84 v3(166.24,159.84)
  L3_SIGNAL w0.178: v1(161.81,169.55) 162.29,169.07 166.03,169.07 166.88,168.23 166.88,161.37 166.49,160.99 166.49,160.1 v3(166.24,159.84)
UNNAMED_12_AD9986V2_I180_TDP: length 14
  L10_SIGNAL w0.178: 160.6,157.86 161.85,157.86 162.38,157.33 v2(162.38,157.15)
  L10_SIGNAL w0.203: 160.6,157.86 159.79,158.68 159.79,161.47 159,162.26 159,165.95 v1(158.61,166.35)
  BOTTOM w0.203: R11AA.1 161.8,155.66 161.8,156.34
  BOTTOM w0.241: 161.8,156.34 161.8,156.56 v2(162.38,157.15)
UNNAMED_12_AD9986V2_I180_VCM0:
  vias: v1(157.81,175.15)
UNNAMED_12_AD9986V2_I180_VCM1:
  vias: v1(157.81,163.15)
UNNAMED_12_CAP_I55_N1: length 1.1
  BOTTOM w0.241: R3AA.2 150.3,169.55 C62AA.1
UNNAMED_13_ADP5056_I64_EN1: length 21.5
  TOP w0.254: U1LL.23 175.42,214.7 arc(175.42,214.7) 175.42,214.71 174.66,214.71 174.28,215.09 v5(174.15,215.09) ; v3(178.97,215.59) 179.37,215.2 U1LL.7 ; v4(175.93,217.68) 175.93,216.91 U1LL.18
  TOP w0.508: R14.2 v3(185.07,216.74) R7LL.2
  L10_SIGNAL w0.508: v4(175.93,217.68) 175.93,217.25 ; 175.93,217.25 175.04,216.36 175.04,215.59 174.53,215.09 v5(174.15,215.09) ; 175.93,217.25 176.18,216.99 177.07,216.99 ; 177.07,216.99 177.2,216.86 177.2,216.36 178.09,215.47 178.85,215.47 v3(178.97,215.59) ; 177.07,216.99 177.91,217.83 v4(179.28,217.83)
  BOTTOM w0.254: 182.27,218.52 179.97,218.52 v4(179.28,217.83)
  BOTTOM w0.305: v3(185.07,216.74) 184.05,216.74 182.27,218.52
UNNAMED_13_CAP_I38_N1: length 1
  BOTTOM w0.241: R44LL.2 C40LL.1
UNNAMED_13_CAP_I113_N1: length 1.2
  BOTTOM w0.241: R1LL.2 C43LL.1
UNNAMED_13_CAP_I114_N1: length 1.2
  TOP w0.305: C9LL.1 183.28,215.21 R51LL.2
UNNAMED_13_CAP_I134_N1: length 0.6
  BOTTOM w0.254: C11.1 R21.2
UNNAMED_13_CAP_I136_N1: length 0.6
  BOTTOM w0.254: C10.1 R20.2
UNNAMED_14_ADP7158_I79_EN: length 3.4
  BOTTOM w0.305: R26.2 R27.2 183.67,225.38 183.15,225.9 U100.5
UNNAMED_14_ADP7158_I79_REF: length 3
  BOTTOM w0.305: C9OO.1 177.82,225.37 178.09,225.37 178.59,225.88 178.75,225.88 ; 178.75,225.88 178.75,226.04 179.11,226.4 U100.7 ; 178.75,225.88 178.77,225.9 U100.6
UNNAMED_14_ADP7158_I79_VIN1: length 8.3
  L10_SIGNAL w0.178: v3(178.21,227.66) 178.21,227.25 180.34,225.12 v2(182.53,225.12)
  BOTTOM w0.241: 179.21,227.4 178.97,227.64 178.97,227.66 179.21,227.9
  BOTTOM w0.305: U100.10 178.86,227.9 178.85,227.91 ; 178.72,227.41 178.73,227.4 U100.9 ; v2(182.53,225.12) 182.67,224.99 R27.1
UNNAMED_14_DIOLED_I76_P: length 44.1
  TOP w0.241: DS100.A v3(147.83,231.85)
  L10_SIGNAL w0.254: v3(147.83,231.85) 149.98,229.69 153.41,229.69 154.68,228.42 164.39,228.42 165.4,229.44 175.31,229.44 176.27,228.47 184.5,228.47 185.01,227.97 185.01,225.18 v3(185.07,225.12)
  BOTTOM w0.305: R700.2 v3(185.07,225.12)
UNNAMED_14_DIOLED_I78_N: length 70.7
  TOP w0.508: v3(147.83,226.65) DS1Q.C
  L10_SIGNAL w0.254: v3(147.83,226.65) 150.11,226.65 150.75,226.01 153.67,226.01 155.19,227.53 162.56,227.53 163.7,226.39 174.88,226.39 176.78,224.49 179.83,224.49 180.46,223.85 185.29,223.85 186.18,224.74 192.02,224.74 193.55,223.22 193.55,207.09 193.13,206.67 v5(193.13,203.53)
  BOTTOM w0.508: R1Q.1 v5(193.13,203.53)
UNNAMED_14_RES_I46_N2: length 2.4
  BOTTOM w0.508: R1Q.2 Q1Q.3
UNNAMED_15_ADP1765_I17_PG: length 5.5
  TOP w0.254: v5(190.37,187.07) U1M.15
  BOTTOM w0.305: v5(190.37,187.07) 190.17,187.27 R29.1
  BOTTOM w0.508: Q1M.1 192.33,188.46 R6M.2 190.57,187.27 v5(190.37,187.07)
UNNAMED_15_ADP1765_I48_PG: length 14.3
  TOP w0.254: U1X.15 177.22,185.12 177.3,185.21 177.3,185.23 v4(177.32,185.24)
  L10_SIGNAL w0.305: v4(177.29,192.1) 177.32,192.07 v4(177.32,185.24)
  BOTTOM w0.305: R30.1 177.29,185.27 v4(177.32,185.24)
  BOTTOM w0.508: R6X.2 v4(177.29,192.1) 176.96,192.43 173.86,192.43 Q1X.1
UNNAMED_15_DIOLED_I75_N: length 78
  TOP w0.508: DS1M.C v5(147.83,225.38)
  L10_SIGNAL w0.254: v5(189.35,193.75) 189.35,195.15 192.53,198.32 192.53,207.34 192.91,207.72 192.91,218.64 191.03,220.52 185.16,220.52 182.98,222.71 175.13,222.71 174.29,221.87 167.26,221.87 162.48,226.65 155.7,226.65 154.43,225.38 v5(147.83,225.38)
  BOTTOM w0.508: v5(189.35,193.75) 189.35,192.87 R7M.2
UNNAMED_15_DIOLED_I76_N: length 44.9
  TOP w0.508: DS1X.C v3(147.83,229.31)
  L3_SIGNAL w0.254: v3(147.83,229.31) 149.52,227.62 149.52,215.55 161.41,203.66 v3(161.41,200.86)
  BOTTOM w0.254: v3(161.41,200.86) 163.7,198.58 168.14,198.58 168.98,197.74
  BOTTOM w0.508: 168.98,197.74 169.76,197.74 R7X.2
UNNAMED_15_RES_I26_N1: length 2.1
  BOTTOM w0.508: Q1M.3 191.39,191.84 R7M.1
UNNAMED_15_RES_I61_N1: length 2.2
  BOTTOM w0.508: Q1X.3 171.7,196.29 170.81,197.19 R7X.1
UNNAMED_17_ADP1765_I15_PG: length 11.1
  TOP w0.254: U1NN.15 171.37,185.29 171.62,185.54 171.62,186.85 R31.1 171.63,188.51 R6NN.2 171.62,188.52 v5(171.62,189.18)
  BOTTOM w0.508: v5(171.62,189.18) 171.62,189.94 168.9,192.65 168.9,193.25 Q1NN.1
UNNAMED_17_DIOLED_I80_P: length 64.5
  TOP w0.241: R10.2 188.77,215.26 v3(188.72,215.22) ; v3(147.83,230.58) DS1P.A
  L3_SIGNAL w0.241: v3(165.35,212.8) 163.07,215.09 151.9,215.09 150.01,216.98 150.01,228.4 v3(147.83,230.58)
  L10_SIGNAL w0.254: v3(188.72,215.22) 186.21,215.22 179.04,208.05 173.28,208.05 170.13,211.2 170.13,211.84 169.16,212.8 v3(165.35,212.8)
UNNAMED_17_DIOLED_I84_N: length 41
  TOP w0.508: v3(147.83,228.04) DS1NN.C
  L3_SIGNAL w0.254: v3(147.83,228.04) 149.02,226.85 149.02,212.37 v3(160.84,200.55)
  BOTTOM w0.254: 165.95,197.69 163.7,197.69 v3(160.84,200.55)
  BOTTOM w0.508: R7NN.2 165.95,197.69
UNNAMED_17_RES_I21_N1: length 1.9
  BOTTOM w0.508: Q1NN.3 R7NN.1
UNNAMED_20_CN400PAKV2_I20_CLK3BIDIRN: length 4.4
  BOTTOM w0.127: 180.09,155.07 181.1,155.07 P1K.J3
  BOTTOM w0.241: 180.09,155.07 179.77,154.75 R2K.1
UNNAMED_20_CN400PAKV2_I24_TDI: length 1.3
  BOTTOM w0.241: P1K.D30 P1K.D31
UNNAMED_20_ICM24CXX_I44_E2: length 4.6
  BOTTOM w0.241: U1K.3 175.84,102.29 175.51,102.62 175.51,104.39 R1K.1
VADJ: length 55.7
  TOP w0.203: C3FF.2 v3(166.09,136.32)
  TOP w0.241: v3(158.77,114.67) C13FF.2 159.48,114.9 U7FF.11 ; U2FF.16 168.91,142.98 169.17,143.24 ; U8FF.11 168.72,114.9 168.48,114.66 167.53,114.66 C14FF.2 168.18,114.67 v3(168.22,114.63) ; v3(151.04,114.67) C12FF.2 151.86,114.9 U6FF.11 ; v1(171.32,140.44) 171.43,140.53 R1FF.1 ; C18FF.2 145.15,102.24 v3(145.52,102.24) 145.62,102.24 145.96,102.58 U10FF.11 ; U3FF.16 168.91,134.85
  TOP w0.305: U5FF.16 168.91,127.12 C9FF.2 169.14,127.41 v1(169.14,128.02) 168.81,128.35 165.89,128.35 165.56,128.68 163.14,128.68 162.82,128.36 C8FF.2 162.56,127.12 U4FF.16
  TOP w0.381: 168.91,134.85 167.43,136.32 v3(166.09,136.32) ; 169.17,143.24 C2FF.2 168.94,144.58 166.8,144.58 166.43,144.21 v5(165.15,144.21)
  TOP w0.508: U1FF.16 168.91,151.08 169.31,151.48 169.31,152.2 v5(167.51,154) 166.9,153.39 C1FF.2
  L10_SIGNAL w0.508: v3(151.04,114.67) 151.46,114.25 158.35,114.25 v3(158.77,114.67)
  BOTTOM w0.203: v3(166.09,136.32) 166.62,135.79 166.62,134.57 169.14,132.05 v1(169.14,128.02)
  BOTTOM w0.241: v3(178.13,154.03) 178.07,154 177.76,154.13 177.72,154.12 R2K.2
  vias: v5(182.97,108.68) v5(184.24,109.95) v5(185.51,108.68) v5(186.78,109.95)
VCO_COARSE:
  vias: v1(154.61,169.55)
VCO_FINE: length 3.3
  BOTTOM w0.127: R3AA.1 151.68,169.93 153.43,169.93
  BOTTOM w0.241: R3AA.1 151.64,169.77 C65AA.1 ; v1(153.81,169.55) 153.43,169.93
VCO_VCM: length 4.1
  BOTTOM w0.127: C65AA.2 151.73,168.38 154.2,168.38
  BOTTOM w0.241: v1(154.61,168.75) 154.57,168.75 154.2,168.38 ; C65AA.2 151.49,168.29 150.94,168.85 C62AA.2
VCO_VREG:
  vias: v1(153.81,168.75)

## Copper pours and planes (outline as drawn)
AVDD1 on TOP: 165.22,178.77 166.11,178.77 166.75,178.13 168.02,178.13 168.02,177.12 167.76,176.86 166.37,176.86 165.22,178
AVDD1 on L5_POWER_ANALOG: 151.64,162 154.68,162 154.68,172.8 155.83,173.94 164.59,173.94 167.64,176.99 167.64,177.88 167,178.51 159.51,178.51 158.62,177.62 156.97,177.62 155.7,176.35 152.02,176.35 151.64,175.97
AVDD1_ADC on TOP: 175.38,176.35 175.38,177.24 175.64,177.5 176.4,177.5 176.4,178.26 174.11,178.26 173.99,178.13 173.99,176.61 174.24,176.35
AVDD1_ADC on L5_POWER_ANALOG: 156.59,171.7 158.11,171.7 158.19,171.78 164.62,171.78 164.62,169.95 164.46,169.8 163.22,169.8 162.76,169.34 162.76,168.28 163.22,167.82 165.22,167.82 166.06,168.66 168.04,168.66 172.16,172.77 172.16,173.53 172.46,173.81 172.46,176.35 174.17,178.39 176.02,178.39 176.02,176.48 175.51,175.72 175.51,161.62 173.48,159.59 154.94,159.59 154.94,168.23 155.06,168.35 156.46,168.35 156.46,171.58
AVDD2 on TOP: 185.42,195.78 185.42,193.37 187.07,193.37 187.07,195.78
AVDD2 on BOTTOM: 185.42,194.51 185.42,193.37 186.94,193.37 186.94,194.51
AVDD2 on L9_POWER_DVDD1: 157.99,177.88 157.99,177.5 170.3,177.5 171.57,178.77 179.96,178.77 181.99,180.8 181.99,191.85 185.42,195.28 186.81,195.28 187.2,194.9 187.2,193.24 184.91,190.96 184.91,174.45 158.37,174.45 158.5,174.32 158.5,172.21 159.13,171.45 159.64,171.45 159.64,170.94 158.37,170.94 155.32,167.89 155.32,166.32 153.03,164.03 153.03,161.88 150.37,161.88 150.37,176.73 153.03,176.73 154.18,177.88
DVDD1 on TOP: 191.26,175.34 191.26,176.99 189.99,176.99 189.23,177.88 187.83,177.88 187.83,175.34 188.08,175.08 189.61,175.08 190.5,175.34
DVDD1 on L9_POWER_DVDD1: 159,170.77 158.88,170.69 158.22,170.03 158.22,166.88 163.95,161.11 191.64,161.11 191.64,177.88 185.42,177.88 185.42,174.32 185.29,174.19 159.13,174.19 159,174.07
GND_SIGNAL on TOP: 146.43,237.24 194.31,237.24 194.31,174.17 194.31,174.17 194.31,116.03 188.21,116.03 188.21,113.87 191.51,113.87 191.77,113.62 191.77,108.21 188.54,108.21 188.54,104.55 188.59,102.31 191.64,102.31 192.15,102.82 194.31,102.82 194.31,99.7 141.6,99.7 141.6,100.33 141.12,101.5 139.95,101.98 130.68,101.98 130.68,102.62 130.21,103.62 129.16,103.99 119.18,103.99 119.18,113.44 123.07,113.44 123.07,114.38 119.18,114.38 119.18,126.93 119.17,126.93 119.17,127.89 119.18,127.89 119.18,140.44 123.07,140.44 123.07,141.38 119.18,141.38 119.18,153.9 119.17,153.9 119.17,154.87 119.18,154.87 119.18,183.44 119.17,183.49 119.17,184.35 119.18,184.38 119.18,196.95 123.19,196.95 123.19,198.07 119.18,198.07 119.18,211.38 119.18,223.93 123.19,223.93 123.19,224.87 119.18,224.87 119.17,234.01 145.29,234.01 146.11,234.46 146.43,235.33 ; 3 cut-outs
GND_SIGNAL on TOP: 177.42,185.62 177.67,185.5 178.43,185.5 178.43,186.26 178.56,186.39 179.32,186.39 179.45,186.51 179.45,187.15 179.32,187.28 177.92,187.28 177.42,186.77
GND_SIGNAL on TOP: 189.13,221.82 190.79,221.82 190.79,225.75 189.13,225.75
GND_SIGNAL on TOP: 184.82,221.44 186.34,221.44 186.34,222.2 185.45,222.2 185.07,222.58 184.82,222.58 184.69,222.45 184.69,221.56
GND_SIGNAL on TOP: 170.72,227.79 175.42,227.79 175.8,228.17 175.8,230.71 175.67,230.83 170.72,230.83
GND_SIGNAL on TOP: 189.64,219.66 189.64,220.93 189.26,221.31 189.26,224.23 190.91,224.23 190.91,221.69 191.42,221.18 192.06,221.18 192.18,221.31 192.18,221.56 192.44,221.82 192.94,221.82 193.07,221.69 193.07,221.34 192.33,220.59 192.33,219.74 192.12,219.53 189.77,219.53
GND_SIGNAL on TOP: 147.05,161.81 149.13,159.67 149.1,159.41 150.16,158.55 150.52,158.62 150.87,159.03 152.02,160.38 151.99,161.16 152.42,162.13 153.11,163.12 152.88,164.29 151.94,165.1 149.17,165.1 146.52,162.45 ; 1 cut-out
GND_SIGNAL on TOP: 149.15,178.65 149.48,179.22 149.81,178.97 150.59,178.97 150.62,179 152.09,177.19 152.37,176.46 152.37,176.05 153.01,175.31 153.03,175.11 153.03,174.17 152.32,173.43 147.98,173.92 146.1,175.62 145.9,175.97 146.66,176.18 ; 1 cut-out
GND_SIGNAL on BOTTOM: 150.66,175.63 150.68,175.66 152.27,174.32 152.16,173.85 152.44,173.12 152.44,172.71 153.07,171.97 153.1,171.77 153.1,170.83 152.39,170.09 148.04,170.58 147.06,171.4 147.7,172.29 149.73,175.08 149.86,175.34 150.11,175.59 ; 2 cut-outs
GND_SIGNAL on BOTTOM: 186.09,207.72 186.09,206.7 186.21,206.58 186.42,206.58 186.54,206.45 186.54,205.74 186.8,205.49 186.8,201.6 186.65,201.45 186.65,200.61 186.98,200.28 188.35,200.28 188.75,200.69 188.75,201.5 188.47,201.78 188.47,206.48 188.78,206.78 188.78,207.82 188.75,207.85 186.21,207.85
GND_SIGNAL on BOTTOM: 194.43,176.1 194.43,99.52 163.78,99.52 163.78,176.1 ; 2 cut-outs
GND_SIGNAL on BOTTOM: 141.35,99.52 141.35,101.91 136.01,101.93 130.81,101.93 130.81,103.96 119.17,103.99 119.17,234.01 146.3,234.01 146.3,237.31 194.43,237.31 194.43,175.85 160.27,175.87 159.61,175.11 159.03,175.13 157.94,174.14 154.91,174.14 153.13,174.17 152.4,174.16 152.4,164.89 153.59,163.58 156.33,163.53 157.26,162.75 158.62,162.43 162.41,162.38 162.28,162.38 163.17,157.33 164.34,155.86 164.08,99.52 ; 12 cut-outs
GND_SIGNAL on BOTTOM: 188.5,221.56 190.91,221.56 190.91,224.36 188.5,224.36
GND_SIGNAL on BOTTOM: 176.69,201.5 182.4,201.5 182.4,207.85 176.69,207.85
GND_SIGNAL on BOTTOM: 180.12,225.75 181.64,225.75 181.64,228.55 182.02,228.93 182.02,230.83 181.77,231.09 180.5,231.09 179.86,230.45 179.86,228.55 180.12,228.29
GND_SIGNAL on BOTTOM: 146.94,167.72 148.56,168.59 152.88,167.93 153.38,167.04 153.13,166.13 153.06,165.94 152.25,165.39 152.15,165 151.69,164.36 149.8,163 149.78,163.03 149.02,163.24 149.35,164.29 147.19,167.21 147.06,167.46 146.94,167.59 ; 2 cut-outs
GND_SIGNAL on BOTTOM: 170.62,230.99 170.62,229.92 170.61,229.91 170.61,228.02 170.71,227.92 173.4,227.92 173.4,229.14 174.09,229.82 174.09,230.89 173.96,231.01 172.64,231.01 172.64,230.99
GND_SIGNAL on L2_GROUND: 141.6,99.7 141.6,100.33 141.12,101.5 139.95,101.98 130.68,101.98 130.68,102.62 130.21,103.62 129.16,103.99 119.18,103.99 119.18,113.44 123.07,113.44 123.07,114.38 119.18,114.38 119.18,126.93 119.17,126.93 119.17,127.89 119.18,127.89 119.18,140.44 123.07,140.44 123.07,141.38 119.18,141.38 119.18,153.9 119.17,153.9 119.17,154.87 119.18,154.87 119.18,168.61 123.19,168.61 123.19,169.72 119.18,169.72 119.18,183.44 119.17,183.49 119.17,184.35 119.18,184.38 119.18,196.95 123.19,196.95 123.19,198.07 119.18,198.07 119.18,211.38 119.18,223.93 123.19,223.93 123.19,224.87 119.18,224.87 119.17,234.01 145.29,234.01 146.11,234.46 146.43,235.33 146.43,237.24 194.31,237.24 194.31,99.7 ; 4 cut-outs
GND_SIGNAL on L3_SIGNAL: 145.06,160.56 145.06,159.97 145.54,159.49 145.54,158.55 148.23,155.86 148.56,155.86 151.28,158.57 151.28,161.98 149.15,164.11 148.61,164.11
GND_SIGNAL on L3_SIGNAL: 143.42,177.93 148.09,173.26 151.24,176.4 151.76,177.12 151.24,177.66 147.19,181.7 146.71,182.2 146.4,182.09 143.41,178.84
GND_SIGNAL on L3_SIGNAL: 157.02,157.53 157.02,152.91 158.62,152.91 159.41,152.3 160.98,152.3 162.05,153.32 162.05,155.73 161.72,156.01 161.75,157.46 161.67,157.71 161.67,158.95 161.57,159.06 158.54,159.06
GND_SIGNAL on L3_SIGNAL: 155.7,179.02 160.14,179.02 161.03,179.91 161.03,186.06 155.7,186.06
GND_SIGNAL on L3_SIGNAL: 119.17,234.01 125.09,234.01 125.09,173.28 125.09,164.97 125.09,103.99 119.18,103.99 119.18,112.7 118.64,112.7 118.64,115.09 119.18,115.09 119.18,126.21 119.18,126.21 119.18,128.6 119.18,128.6 119.18,139.73 118.64,139.73 118.64,142.09 119.18,142.09 119.18,153.21 119.18,153.21 119.18,164.97 119.17,168 118.64,168 118.64,170.36 119.17,170.36 119.17,174.02 119.18,174.02 119.18,182.73 119.17,182.75 119.17,185.07 119.18,185.09 119.18,196.22 118.64,196.22 118.64,198.58 119.18,198.58 119.18,209.73 119.17,209.75 119.17,212.04 119.18,212.09 119.18,223.22 118.64,223.22 118.64,225.58 119.18,225.58
GND_SIGNAL on L4_GROUND: 141.6,99.7 141.6,100.33 141.12,101.5 139.95,101.98 130.68,101.98 130.68,102.62 130.21,103.62 129.16,103.99 119.18,103.99 119.18,173.28 119.17,234.01 145.29,234.01 146.11,234.46 146.43,235.33 146.43,237.24 194.31,237.24 194.31,99.7
GND_SIGNAL on L5_POWER_ANALOG: 141.6,99.7 141.6,100.33 141.12,101.5 139.95,101.98 130.68,101.98 130.68,102.62 130.21,103.62 129.16,103.99 119.18,103.99 119.17,234.01 145.29,234.01 146.11,234.46 146.43,235.33 146.43,237.24 146.56,237.31 165.73,237.31 165.73,212.55 165.22,212.04 142.87,212.04 142.11,211.28 142.11,209.63 142.62,209.12 165.99,209.12 166.11,208.99 166.11,207.72 168.91,204.93 168.91,202.9 172.84,198.96 183.64,198.96 184.02,198.58 183.89,191.9 183.28,191.37 183.28,189.23 183.26,183.82 180.49,181.1 174.95,181.1 173.68,180.29 172.59,180.29 172.59,182.58 172.08,182.96 170.69,182.96 168.02,180.42 166.11,180.42 165.1,179.4 160.4,179.4 160.39,179.41 159.62,179.41 158.14,177.93 156.26,177.93 155.19,176.86 148.71,176.86 148.59,176.73 148.59,162.89 152.4,159.08 163.7,159.08 163.83,158.95 173.73,158.95 176.15,161.37 176.15,175.72 176.53,176.1 176.53,179.4 181.61,179.4 185.29,183.08 185.29,189.43 187.83,189.43 187.83,115.65 187.2,115.01 187.2,99.77
GND_SIGNAL on L6_GROUND: 141.6,99.7 141.6,100.33 141.12,101.5 139.95,101.98 130.68,101.98 130.68,102.62 130.21,103.62 129.16,103.99 119.18,103.99 119.18,164.97 119.17,173.28 119.17,234.01 145.29,234.01 146.11,234.46 146.43,235.33 146.43,237.24 194.31,237.24 194.31,99.7
GND_SIGNAL on L7_POWER_DIGITAL: 141.6,99.7 141.6,100.33 141.12,101.5 139.95,101.98 130.68,101.98 130.68,102.62 130.21,103.62 129.16,103.99 119.18,103.99 119.17,234.01 145.29,234.01 146.11,234.46 146.43,235.33 146.43,237.24 194.31,237.24 194.31,99.7
GND_SIGNAL on L8_GROUND: 141.6,99.7 141.6,100.33 141.12,101.5 139.95,101.98 130.68,101.98 130.68,102.62 130.21,103.62 129.16,103.99 119.17,103.99 119.17,234.01 145.29,234.01 146.11,234.46 146.43,235.33 146.43,237.24 194.31,237.24 194.31,99.7
GND_SIGNAL on L9_POWER_DVDD1: 146.43,237.24 194.31,237.24 194.31,229.57 194.31,229.56 194.31,99.7 141.6,99.7 141.6,100.33 141.12,101.5 139.95,101.98 130.68,101.98 130.68,102.62 130.21,103.62 129.16,103.99 119.18,103.99 119.18,234.01 145.29,234.01 146.11,234.46 146.43,235.33
GND_SIGNAL on L10_SIGNAL: 153.16,159.72 152.02,158.57 152.02,152.86 158.11,152.86 158.11,159.72
GND_SIGNAL on L10_SIGNAL: 155.7,178.13 159.76,182.2 159.76,184.99 153.67,184.99 153.67,178.13
GND_SIGNAL on L10_SIGNAL: 119.17,234.01 125.09,234.01 125.09,103.99 119.17,103.99 119.17,126.21 118.64,126.21 118.64,128.6 119.17,128.6 119.17,153.21 118.64,153.21 118.64,155.58 119.17,155.58 119.17,182.73 118.64,182.73 118.64,185.09 119.17,185.09 119.17,209.73 118.64,209.73 118.64,212.09 119.17,212.09
GND_SIGNAL on L10_SIGNAL: 146.94,160.61 143.38,165.56 148.46,169.37 148.84,169.5 152.78,164.67
GND_SIGNAL on L10_SIGNAL: 144.27,176.35 144.27,173.69 144.78,173.18 149.22,170.26 150.11,170.38 152.91,174.7 152.52,175.46 146.56,178.77
GND_SIGNAL on L11_GROUND: 141.6,99.7 141.6,100.33 141.12,101.5 139.95,101.98 130.68,101.98 130.68,102.62 130.21,103.62 129.16,103.99 119.18,103.99 119.18,126.95 123.07,126.95 123.07,127.87 119.18,127.87 119.18,155.27 123.07,155.27 123.07,156.29 119.18,156.29 119.18,183.59 123.07,183.59 123.07,184.61 119.18,184.61 119.18,210.44 123.19,210.44 123.19,211.38 119.18,211.38 119.18,234.01 145.29,234.01 146.11,234.46 146.43,235.33 146.43,237.24 194.31,237.24 194.31,99.7 ; 4 cut-outs
1P5V_A on TOP: 175.44,206.25 175.26,206.02 175.26,198.32 177.54,198.32 177.58,198.07 177.54,195.78 177.54,193.88 176.4,192.99 173.73,192.99 172.97,193.75 172.97,195.66 172.21,196.42 167.13,196.42 166.37,195.66 165.61,194.64 164.46,194.64 162.3,196.8 162.3,197.05 157.48,201.88 157.48,202.13 153.92,206.07 153.92,208.48 155.57,210.14 165.86,210.14 166.62,209.37 169.67,209.37 169.67,207.29 175.44,207.29
1P5V_A on BOTTOM: 170.43,203.66 170.43,198.45 173.35,198.45 173.35,203.66
1P5V_D on TOP: 183.55,196.67 181.63,194.75 181.63,192.25 181.61,192.23 181.61,187.91 181.23,187.53 177.8,187.53 177.42,187.91 177.42,190.83 178.05,191.47 178.05,195.4 177.8,195.66 177.8,198.32 179.7,198.32 179.7,207.32 184.78,207.32 184.78,209.7 192.15,209.7 192.15,197.56 191.26,196.67
1P5V_D on BOTTOM: 180.08,200.86 180.46,201.25 183,201.25 183.39,200.86 183.26,196.29 182.5,195.4 182.5,195.02 182.37,187.66 179.07,187.66 178.43,188.29 178.43,194.01 180.08,195.66
1P5V_SW1 on TOP: 178.21,215.09 178.21,209.85 179.58,208.48 179.58,207.55 184.48,207.55 184.48,209.63 183.13,209.63 182.88,209.88 179.32,209.88 178.85,210.36 178.85,215.09
1P5V_SW2 on TOP: 177.2,209.92 177.2,215.09 176.56,215.09 176.56,210.42 176.15,210.01 174.28,210.01 174.27,210.01 170.3,210.01 169.92,209.63 169.92,207.55 175.64,207.55 175.64,208.36
3P3V on L3_SIGNAL: 177.29,188.8 181.35,184.74 188.21,184.74 189.1,183.85 189.1,143.97 189.74,143.33 189.74,140.03 188.97,139.27 188.97,120.98 185.8,117.81 185.8,110.06 187.83,108.03 189.1,108.03 191.51,110.44 191.51,189.69 189.74,191.47 178.56,191.47 177.29,190.2
3P3V_HMC on TOP: 174.24,110.69 174.24,109.04 176.53,109.04 176.53,110.69
3P3V_HMC on BOTTOM: 182.15,226.77 185.71,226.77 185.71,231.09 182.91,231.09 182.91,228.8 182.15,228.04
3P3V_HMC on L3_SIGNAL: 185.67,196.67 191.89,190.45 191.89,109.68 189.74,107.52 187.45,107.52 184.66,110.31 176.53,110.31 175.26,111.58 175.26,118.57 174.11,119.71 172.34,119.71 171.19,118.57 174.37,115.39 174.37,102.31 173.86,101.8 156.72,101.8 154.05,104.47 153.92,104.47 153.92,123.39 151.89,125.43 150.11,125.43 148.71,124.03 148.71,119.84 147.57,118.7 146.3,118.7 144.14,120.85 143.51,120.85 143.25,120.6 143.25,119.58 145.03,117.81 147.7,117.81 149.98,120.09 149.98,124.03 150.24,124.28 151.13,124.28 152.02,123.39 152.02,101.04 153.41,99.65 192.4,99.65 194.43,101.68 194.43,224.11 189.99,228.55 182.88,228.55 182.12,227.79 182.12,222.96 191.39,213.69 191.39,202.9 185.67,197.18
3P8V on TOP: 177.5,230.78 179.66,230.78 179.86,230.58 179.86,223.21 179.83,223.21 179.83,223.09 179.45,222.71 176.53,222.71 175.8,221.98 175.8,218.39 175.67,218.26 174.78,218.26 174.53,218.52 174.53,219.66 174.02,220.17 169.45,220.17 168.43,219.15 167.16,219.15 166.91,219.4 166.91,222.05 165.39,223.57 165.39,225.65 165.87,226.14 170.34,226.14 170.85,226.64 173.99,226.64 173.99,226.65 176.53,226.65 177.07,227.19 177.07,230.35
3P8V on BOTTOM: 179.36,229.18 176.94,229.18 176.94,230.71 177.2,230.96 178.85,230.96 179.36,230.45
3P8V on BOTTOM: 170.72,226.77 173.64,226.77 173.64,222.71 173.13,222.2 170.85,222.2 170.34,222.71 170.34,226.39
3P8V on BOTTOM: 186.47,204.04 185.2,204.04 184.31,204.93 184.31,209.12 185.07,209.88 186.85,209.88 187.1,209.63 187.1,208.1 186.09,208.1 185.96,207.97 185.96,206.22 185.97,206.21 185.96,205.05 186.47,204.55
3P8V on L7_POWER_DIGITAL: 139.57,229.82 150.11,229.82 150.11,218.77 151.64,217.25 160.53,217.25 160.53,206.96 161.8,205.69 181.35,205.69 183,207.34 183,215.47 178.43,220.04 175.77,220.04 174.88,219.15 167.13,219.15 165.35,220.93 165.35,225.63 165.86,226.14 171.32,226.14 176.4,231.22 188.34,231.22 191.77,227.79 193.93,227.79 193.93,201.12 159,201.12 157.22,202.9 157.22,210.39 155.83,211.79 139.57,211.79
3P8V_SW3 on TOP: 178.21,221.08 179.36,221.08 179.99,220.42 179.99,219.79 178.34,219.79 178.24,219.74 178.24,217.53 178.09,217.37 177.65,217.37 177.63,217.35 177.63,216.61 177.58,216.56 177.32,216.56 177.25,216.64 177.25,217.32 177.04,217.53 177.04,222.3 177.2,222.45 178.09,222.45 178.21,222.33
12P0V_1 on TOP: 189.1,107.77 189.1,102.69 191.13,102.69 191.13,107.77
12P0V_1 on TOP: 179.1,210.48 179.45,210.13 180.5,210.13 180.5,211.78 179.61,211.78 179.61,214.96 179.1,214.96
12P0V_1 on TOP: 176.31,210.55 176.31,214.96 175.8,214.96 175.8,211.91 174.78,211.91 174.78,210.26 176.02,210.26 176.02,210.26
12P0V_1 on TOP: 162.05,231.47 165.63,231.47 165.63,235.3 162.05,235.31
12P0V_1 on BOTTOM: 178.59,213.82 178.59,208.36 183.04,208.36 183.04,213.82
12P0V_1 on BOTTOM: 174.78,217.63 178.85,217.63 178.85,219.4 174.78,219.4
12P0V_1 on BOTTOM: 163.19,237.19 178.43,237.19 178.69,236.93 178.69,234.01 173.28,234 172.08,235.15 165.73,235.15 165.2,234.67 165.2,231.14 164.92,230.86 162.3,230.86 161.87,231.29 161.87,235.99 162.05,236.15
12P0V_1 on BOTTOM: 172.37,213.69 172.37,209.12 176.69,209.12 176.69,213.69
12P0V_1 on L3_SIGNAL: 180.34,237.31 182.12,235.54 193.42,235.54 194.05,234.9 194.05,229.57 193.8,229.31 180.97,229.31 178.56,231.73 177.29,231.73 175,234.01 173.61,234.01 173.1,234.52 173.1,236.68 173.73,237.31
12P0V_1 on L5_POWER_ANALOG: 166.75,237.19 192.78,237.19 194.31,235.66 194.31,172.92 194.31,169.88 194.31,107.31 194.31,102.31 188.21,102.31 187.7,102.82 187.7,114.63 188.34,115.27 188.34,196.93 185.93,199.34 173.23,199.34 169.42,203.15 169.42,205.44 166.75,208.1 166.75,209.25 166.24,209.75 143,209.75 142.75,210.01 142.75,210.9 143,211.15 166.11,211.15 166.75,211.79
12P0V_FMC on TOP: 188.47,115.77 194.18,115.77 194.18,103.84 193.67,103.33 192.66,103.33 192.15,103.84 192.15,113.74 191.77,114.12 188.47,114.12
A1P0V_INN on TOP: 169.54,186.39 169.42,186.26 167.51,186.26 167.51,189.56 166.24,189.56 166.24,192.74 167,193.5 169.92,193.5 170.3,193.12 170.3,187.91 169.54,187.15
A1P0V_SNS on TOP: 169.67,184.35 170.3,184.35 171.7,182.96 173.35,182.96 173.35,180.8 174.24,180.8 174.24,179.91 175.38,179.91 175.38,178.51 171.7,178.51 171.7,181.05 170.69,181.05 170.3,181.31 169.29,181.31 169.03,181.05 169.03,178.89 166.37,178.89 166.37,183.47 166.75,183.85 166.86,183.99 166.88,183.97 169.54,183.97
A2P0V_INP on TOP: 188.88,222.45 187.86,222.45 187.48,222.07 186.59,222.07 186.59,221.06 184.82,221.06 184.18,221.69 184.18,223.72 183.55,224.36 182.15,224.36 182.15,221.56 184.18,219.53 188.75,219.53 189.01,219.79 189.01,221.06 188.88,221.18
AIN1 on TOP: 187.83,187.91 185.72,187.91 185.72,187.99 185.16,188.55 184.78,188.55 184.27,189.05 184.27,192.1 184.53,192.36 188.72,192.36 188.97,192.1 188.97,190.45 188.47,189.94 188.47,188.55
AIN1 on BOTTOM: 184.91,189.82 184.91,187.78 188.72,187.78 188.72,189.82
AIN2 on TOP: 185.8,185.75 187.83,185.75 188.15,185.43 188.15,183.59 188.47,183.28 188.47,182.07 188.59,181.94 189.61,181.94 190.5,181.05 190.5,180.04 191.77,178.77 192.66,178.77 192.78,178.64 192.78,177.88 192.4,177.5 190.5,177.5 189.74,178.26 188.08,178.26 187.7,178.64 187.7,180.8 187.32,181.18 185.93,181.18 185.04,182.07 185.04,184.23 185.8,184.99
AIN2 on BOTTOM: 184.91,185.75 184.91,181.43 188.72,181.43 188.72,185.75
AIN5 on TOP: 175.33,181.74 176.27,181.74 176.4,181.87 176.4,183.72 176.53,183.85 176.91,183.85 176.91,184.74 176.4,184.74 176.05,185.17 176.05,186.41 176.3,186.67 176.3,187.43 176.5,187.63 176.96,187.63 177.01,187.68 177.01,188.93 176.63,189.31 174.75,189.31 174.37,188.93 174.37,182.7
AIN6 on TOP (solid shape): 185.54,179.15 184.27,179.15 184.27,181.05 185.54,181.05
AIN6 on TOP: 180.59,184.86 180.59,183.08 181.66,182.07 183.77,182.07 184.4,181.43 185.16,181.43 185.54,181.05 185.54,178.77 184.4,177.62 182.5,177.62 181.86,178.26 180.85,178.26 179.58,179.53 179.58,180.67 179.55,180.67 178.92,181.31 178.92,181.33 178.51,181.74 178.51,183.72 178.56,183.85 178.56,184.23 179.07,184.61 179.7,184.61 179.96,184.86
AIN6 on BOTTOM: 179.32,184.1 181.48,184.1 181.48,181.69 184.15,181.69 184.15,179.78 179.32,179.78
AIN14 on TOP: 192.31,222.96 191.17,222.96 191.17,222.58 192.06,222.58 192.31,222.33 193.2,222.33 193.45,222.07 193.45,221.41 192.89,220.85 192.89,215.01 193.04,214.86 193.7,214.86 193.85,215.01 193.85,220.5 194.13,220.78 194.13,222.91 193.58,223.47 192.81,223.47
AIN14 on L5_POWER_ANALOG: 165.05,169.57 163.42,169.57 162.94,169.09 162.94,168.48 163.29,168.12 165.2,168.12 165.86,168.78 167.76,168.78 171.91,172.92 171.91,176.07 173.91,178.49 175.28,179.71 181.4,179.76 184.88,183.24 184.91,189.87 185.37,190.48 185.42,194.92 185.75,195.23 187.27,195.23 187.27,196.45 185.34,196.45 184.33,195.43 184.33,191.59 183.69,191.06 183.74,183.75 180.67,180.72 175.08,180.72 172.69,179.2 170.97,177.47 170.97,173.94 170.84,173.81 170.84,173.31 167.43,169.9 165.38,169.9
BVDD2 on TOP: 184.78,195.78 184.91,195.66 184.91,193.88 184.66,193.63 183.84,193.63 183.59,193.37 182.12,193.37 181.86,193.63 181.86,195.53 182.12,195.78
BVDD2 on BOTTOM: 182.88,193.63 182.88,195.28 183.26,195.66 184.4,195.66 184.4,193.88 183.77,193.24 183.26,193.24
BVDD2 on L9_POWER_DVDD1: 180.08,175.72 157.6,175.72 156.46,174.58 156.46,164.67 158.49,162.64 160.4,162.64 160.65,162.89 160.65,163.91 157.86,166.7 157.86,170.13 158.62,170.89 158.62,174.07 159,174.45 184.78,174.45 185.04,174.7 185.04,178.26 189.86,183.08 189.86,196.04 189.35,196.55 182.75,196.55 181.61,195.4 181.61,194.26 182.75,193.12 183.64,193.12 184.66,194.13 184.66,194.77 185.54,195.66 186.94,195.66 187.7,194.9 187.7,183.34
CLKVDD1 on TOP: 169.29,180.8 171.45,180.8 171.45,179.78 170.56,179.78 170.56,178.26 170.69,178.13 170.69,177.62 170.43,177.37 169.54,177.37 169.16,177.75 169.16,178.51 169.29,178.64
CLKVDD1 on L10_SIGNAL: 159.38,181.05 161.8,181.05 163.7,179.15 169.03,179.15 169.29,179.4 170.56,179.4 170.56,178 170.43,177.88 163.45,177.88 161.67,179.66 160.14,179.66 158.75,178.26 158.75,173.31 157.99,172.8 157.99,171.91 160.78,169.11 160.78,167.21 160.27,166.7 158.49,166.7 157.86,166.07 157.86,164.29 157.35,163.78 155.83,163.78 154.56,165.05 154.56,174.32 155.32,175.08 155.32,176.99
D1P0V on TOP: 187.45,175.34 187.45,177.24 185.42,177.24 185.29,177.12 185.29,176.48 185.42,176.35 186.05,176.35 186.18,176.23 186.18,175.46 186.31,175.34
D1P0V on L7_POWER_DIGITAL: 161.41,174.19 163.19,176.1 165.35,176.1 167.38,174.07 178.94,174.07 181.23,176.35 181.23,178 182.24,179.02 186.81,179.02 187.58,178.26 187.58,175.34 187.2,174.96 185.67,174.96 185.29,175.34 185.29,177.12 184.78,177.62 183.26,177.62 183,177.37 183,171.78 173.48,162.26 169.03,162.26 168.99,162.31 165.35,162.31 165.1,162.05 161.41,162.05
D1P8V on BOTTOM: 189.39,207.97 189.13,207.72 189.13,206.58 188.75,206.2 188.75,204.04 189.77,204.04 190.79,205.05 191.42,205.05 191.55,205.18 191.55,207.09 190.66,207.97
D1P8V on L3_SIGNAL: 161.29,174.45 161.54,174.19 170.56,174.19 174.37,178 174.37,181.94 174.31,182.01 174.31,189.88 174.24,189.94 174.37,190.07 174.37,193.24 177.92,196.8 183.89,196.8 190.75,203.66 190.75,207.47 189.74,208.48 183,208.48 177.8,203.28 176.78,203.28 168.02,212.04 165.1,212.04 162.68,214.45 154.68,214.45 154.05,213.82 154.05,213.18 166.75,200.48 166.75,191.34 164.97,189.56 164.97,188.29 164.21,187.53 164.21,185.75 166.88,183.08 166.88,179.53 166.3,178.96 162.24,178.96 161.67,179.53 161.16,179.53 160.53,178.89 160.53,177.62 161.29,176.86
D1P8V on L7_POWER_DIGITAL: 142.11,148.54 142.11,142.57 143.51,141.17 143.51,138.38 142.11,136.98 142.11,119.92 142.52,119.51 158.77,119.51 159.64,120.37 159.64,127.08 157.99,128.73 157.99,128.86 157.86,128.98 154.18,128.98 154.18,135.59 154.68,136.09 161.29,136.09 162.05,136.86 162.1,136.86 162.1,142.06 162.94,142.9 162.94,144.98 150.37,144.98 149.6,145.75 149.6,149.94 150.49,150.83 162.94,150.83 162.94,152.91 162.96,152.91 162.96,158.57 163.73,159.34 164.56,159.34 170.91,152.99 170.91,152.88 174.88,148.92 174.88,108.97 174.88,108.97 175.21,108.64 175.21,99.9 142.36,99.9 140.71,102.19 134.74,102.19 134.75,148.54
D1P8V on L9_POWER_DVDD1: 152.14,212.17 145.41,218.9 142.75,218.9 142.36,219.28 142.36,219.91 142.62,220.17 145.67,220.17 151.13,214.71 155.57,214.71 156.21,214.07 156.21,212.8 155.57,212.17
D1P8V on L10_SIGNAL: 161.67,178.26 161.67,179.15 161.41,179.4 160.53,179.4 159.26,178.13 159.26,173.69 160.27,172.67 161.92,172.67 162.05,172.54 162.05,171.65 160.65,171.65 160.14,172.16 159.51,172.16 159.13,172.54 158.49,172.54 158.24,172.29 158.24,172.16 159.38,171.02 159.38,170.77 160.27,169.88 162.05,169.88 162.05,169.24 161.41,168.61 161.41,163.78 161.67,163.53 163.57,163.53 163.7,163.65 163.7,167.21 163.19,167.72 163.19,168.23 163.7,168.73 163.7,174.58 163.19,175.08 160.91,175.08 160.65,175.34 160.65,177.24
DAVDD1 on TOP: 181.99,177.88 178.81,177.88 178.69,177.75 178.69,177.37 178.81,177.24 179.7,177.24 179.83,177.12 179.83,176.23 179.96,176.1 181.73,176.1 181.99,176.35
DAVDD1 on L7_POWER_DIGITAL: 158.11,178.64 169.54,178.64 170.05,178.13 180.34,178.13 180.85,177.62 180.85,176.48 178.69,174.32 167.51,174.32 167.26,174.58 167.26,174.7 165.61,176.35 162.81,176.35 161.03,174.58 161.03,165.05 160.4,164.42 155.95,164.42 154.94,165.43 154.94,166.96 155.95,167.97 157.6,167.97 157.99,168.35 157.99,170.77 157.35,171.4 154.94,171.4 154.68,171.65 154.68,173.56 157.1,175.97 157.1,177.62
DCLKVDD1 on TOP: 184.4,175.34 184.4,177.24 182.37,177.24 182.24,177.12 182.24,176.48 182.37,176.35 183,176.35 183.13,176.23 183.13,175.46 183.26,175.34
DCLKVDD1 on L7_POWER_DIGITAL: 157.05,170.99 157.53,170.51 157.53,168.66 157.25,168.38 156.18,168.38 156.16,168.35 155.83,168.35 154.56,167.08 154.56,165.3 155.83,164.03 161.03,164.03 161.03,162.05 161.29,161.8 174.11,161.8 183.3,170.98 183.3,176.77 183.51,176.99 184.4,176.99 184.78,176.61 184.78,175.21 185.04,174.96 185.04,169.75 175.54,160.25 175.51,160.25 175.11,159.84 153.16,159.84 149.86,163.15 149.86,169.11 151.51,170.77 153.24,170.77 153.46,170.99
HMC_3P3V on L9_POWER_DVDD1: 139.25,116.98 140.97,115.27 140.97,105.61 139.57,104.34 139.32,104.09 139.32,103.71 139.57,103.46 141.09,103.46 141.98,104.34 141.98,106.88 142.75,107.65 148.33,107.65 148.97,108.28 148.97,108.92 147.95,109.93 147.95,119.08 147.06,119.97 146.56,119.97 146.17,119.58 146.17,118.31 145.41,117.55 144.4,117.55 143.63,118.31 143.62,118.3 139.72,118.3 139.25,117.83
HMC_3P3V_PLL on TOP: 173.73,112.22 173.73,109.55 171.83,109.55 171.83,112.22
HMC_3P3V_PLL on L9_POWER_DVDD1: 149.98,105.74 149.6,106.12 149.6,109.04 148.46,110.19 148.46,119.58 147.57,120.47 146.17,120.47 145.67,119.97 145.67,118.57 145.16,118.06 145.03,118.06 144.27,118.82 144.27,120.35 143.54,121.08 143.54,122.5 143.53,122.5 143.53,122.89 145.05,124.41 148.46,124.41 151.76,121.11 151.76,119.97 154.68,117.04 157.86,117.04 157.86,115.27 158.37,114.76 170.81,114.76 172.84,112.73 172.84,111.46 172.21,110.82 167.51,110.82 166.43,111.9 155.26,111.9 154.3,110.95 152.27,110.95 151.76,110.44 151.76,108.03 152.91,106.88 152.91,106.12 152.52,105.74
HMC_3P3V_VCO on L9_POWER_DVDD1: 144.43,126.95 152.02,126.95 160.91,118.06 168.02,118.06 168.27,117.81 168.27,117.04 168.15,116.92 159.26,116.92 151.25,124.92 145.07,124.92 138.85,118.7 138.85,116.5 140.33,115.01 140.33,113.87 139.82,113.36 138.17,113.36 136.71,114.82 136.71,119.22 144.43,126.93
Net_7 on L3_SIGNAL: 183.26,213.18 183.51,212.93 183.51,208.87 185.42,208.87 185.42,210.14 186.69,211.41 186.69,215.72 186.18,216.23 184.27,216.23 183.26,215.22
PLLCLKVDD1 on L5_POWER_ANALOG: 156.08,168.86 154.94,168.86 154.94,172.67 155.7,173.43 165.73,173.43 168.02,175.72 168.02,179.91 170.81,182.45 172.08,182.45 172.08,181.69 169.29,179.15 169.29,173.81 167.51,172.04 156.46,172.04 156.08,171.65
UNNAMED_6_CAP_I34_N1 on BOTTOM: 166.62,117.68 166.62,113.62 164.46,113.62 164.46,117.68
UNNAMED_8_AD71758_I49_AVDD1 on BOTTOM: 145.16,211.15 145.16,212.29 144.78,212.68 144.78,213.95 144.14,213.95 143.76,213.56 143.76,212.8 143,212.04 143,211.66 143.13,211.53 143.63,211.53 144.02,211.15
UNNAMED_13_CAP_I10_N2 on BOTTOM: 176.56,233.09 171.82,233.09 171.6,232.87 171.6,231.85 171.73,231.73 176.69,231.73 176.69,232.96
UNNAMED_13_CN3P_I4_N1 on BOTTOM: 157.48,222.84 155.57,222.84 154.56,223.85 154.56,224.69 160.07,230.2 165.1,230.2 165.48,229.82 165.48,227.79 163.7,226.01 160.78,226.01 158.75,223.98
UNNAMED_14_ADP7158_I79_VIN1 on BOTTOM: 179.1,227.28 179.1,228.8 176.18,228.8 175.8,229.18 175.8,230.71 175.55,230.96 174.66,230.96 174.28,230.58 174.28,227.79 174.78,227.28
UNNAMED_15_FERRITE_I56_N1 on TOP (solid shape): 187.32,177.62 186.31,177.62 186.31,180.54 187.32,180.54
VADJ on L5_POWER_ANALOG: 178.81,155.4 178.81,150.83 175.64,150.83 172.97,148.16 172.97,119.58 172.84,119.58 172.84,113.11 175.21,110.74 187.2,110.74 187.2,107.01 186.23,106.05 181.48,106.05 181.48,105.11 180.11,103.73 180.11,101.83 179.58,101.3 144.9,101.3 144.57,101.63 144.57,102.92 144.98,103.33 156.46,103.33 157.99,104.85 157.99,115.39 164.46,115.39 166.49,117.43 166.49,141.94 164.34,144.1 164.34,154.51 165.22,155.4

## Text on the board
Ref Des/Silkscreen Bottom: ADC0/NONE | ADC1/NONE
User.Comments: IS LOCATED IN THE ASSEMBLY FOLDER. | 4.    HEATSINK INSTALLATION INSTRUCTIONS (15-051884-01-A) FOR U1AA
Ref Des/Silkscreen Top: ADC3/ADC1 | AD9081-FMCB-EBZ | AD9082-FMCB-EBZ | AD9177-FMCB-EBZ | AD9207-FMCB-EBZ | AD9209-FMCB-EBZ | AD9986-FMCB-EBZ | AD9988-FMCB-EBZ | ALTERNATE | DAC | BALUNS | DVDD1P0V | A2P0V | D1P0V | A1P0V | 3P3V | 3P8V | ADC | 0 | 3 | 5 | 4 | 7 | 6 | 9 | 8 | 10 | GND | 11 | 20 | 21 | DAC1 | DAC2 | ADC1/NONE | ADC2/ADC0 | ADC0/NONE
PAGE_OUTLINE: B | C | CHANGE PER ECR-084936 | CHANGE PER ECR-096196 | 29JAN20 | 19JUN20 | D.J. | P.H. | EVALUATION BOARD
User.15: CHARACTERISTIC IMPEDANCE = 50 OHMS DIFF +/- 10% | ARTWORK LINE WIDTH FOR | IMPEDANCE CONTROLLED LINES = 0.030" FOR L1 AND L12 | IMPEDANCE CONTROLLED LINES = 0.0070" FOR L3 AND L10 | DIFFERENTIAL IMPEDANCE = 100 OHMS +/- 10% | IMPEDANCE CONTROLLED LINES = 0.0040" FOR L1 AND L12 | IMPEDANCE CONTROLLED LINES = 0.00525" FOR L3 AND L10 | 0.005" TACHYON | 16.    DUE TO CONGESTION CLIPPING OF SILKSCREEN ALLOWED.
User.17: L2 GROUND | 08-      -07
User.18: L3 SIGNAL | 08-      -08
User.19: L4 GROUND | 08-      -09
