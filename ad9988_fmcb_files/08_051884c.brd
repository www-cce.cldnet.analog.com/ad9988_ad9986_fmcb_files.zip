# Allegro board 08_051884c.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
1P5V_A: length 75.3
  TOP w0.305: L2LL.2 168.56,204.93 v4(168.05,205.44)
  TOP w0.508: v3(167.51,210.2) R10LL.2
  L4_GROUND w0.305: v3(167.51,210.2) 168.05,209.66 v4(168.05,205.44)
  L10_SIGNAL w0.203: v2(148.59,221.44) 147.06,219.91 145.67,219.91 144.65,218.9 ; 145.41,221.44 v2(146.17,221.44)
  L10_SIGNAL w0.254: v3(159.83,204.1) 155.45,208.48 147.44,208.48 143.51,212.42 143.51,219.53 145.41,221.44 ; 144.65,218.9 144.65,213.56 148.33,209.88 156.72,209.88 v3(161.41,205.18)
  BOTTOM w0.254: U1.26 146.81,220.81 v2(146.17,221.44) ; U1.30 148.81,221.22 v2(148.59,221.44)
  BOTTOM w0.305: v3(167.51,210.2) 167.51,209.74 167.82,209.44 C10.2 168.02,209.4
  BOTTOM w0.508: 168.02,205.47 v4(168.05,205.44)
  vias: v5(171.07,203.15) v5(171.07,202.13) v5(171.07,201.12) v5(171.07,200.23) v5(171.07,199.21) v5(171.96,203.15) v5(171.96,202.13) v5(171.96,201.12) v5(171.96,200.23) v5(171.96,199.21)
1P5V_BST1: length 2
  TOP w0.203: U1LL.12 178.95,216.38 v3(178.67,216.1)
  BOTTOM w0.508: C11LL.1 178.59,216.27 178.59,216.18 v3(178.67,216.1)
1P5V_BST2: length 2.3
  TOP w0.203: v5(176.18,215.98) 176.45,216.25 U1LL.17
  BOTTOM w0.508: v5(176.18,215.98) 175.89,216.27 C12LL.2
1P5V_COMP1: length 2.6
  TOP w0.241: 181.27,215.11 R51LL.1
  TOP w0.254: 181.27,215.11 181.27,214.2 181.26,214.2 U1LL.5
  TOP w0.279: C10LL.1 arc(181.27,214.07) 181.26,214.2
1P5V_COMP2: length 8.3
  TOP w0.241: v3(173.77,214.58) 173.89,214.45 174.28,214.45 174.52,214.2 U1LL.24
  L10_SIGNAL w0.178: v3(173.77,214.58) 173.26,214.07 173.26,210.64 v3(172.88,210.26)
  BOTTOM w0.241: R1LL.1 172.23,209.12 172.23,210.25 C2LL.1 v3(172.88,210.26)
1P5V_D: length 57.5
  L4_GROUND w0.305: v4(182.78,200.35) 182.78,208.39 v3(184.78,210.39)
  L10_SIGNAL w0.254: v2(149.98,212.68) 151.38,211.28 159,211.28 166.19,204.09 172.29,204.09 173.23,203.15 173.23,198.25 179.7,191.77 v4(179.7,190.32)
  BOTTOM w0.254: v2(149.98,212.68) 149.35,212.68 148.31,213.72 U1.2
  BOTTOM w0.305: C11.2 184.34,209.69 184.78,210.14 v3(184.78,210.39)
  vias: v4(179.7,187.91) v4(180.85,189.05) v4(180.85,187.91) v4(181.77,200.35) v4(181.77,199.21) v4(181.77,198.07) v4(181.77,197.05) v4(181.77,196.04) v4(182.78,199.21) v4(182.78,198.07)
1P5V_FB1: length 6.2
  TOP w0.279: v5(183.8,211.65) R21LL.2 182.01,212.8
  TOP w0.305: 182.01,212.8 181.39,212.8 180.48,213.7 U1LL.4
  TOP w0.508: v5(183.8,211.65) 184.51,212.36 184.78,212.36
  BOTTOM w0.254: R21.1 183.86,211.59 v5(183.8,211.65)
1P5V_FB2: length 10.1
  TOP w0.241: U1LL.25 175.45,213.7 arc(175.43,213.7) 175.42,213.69 ; v6(174.02,213.69) 173.64,214.07 173.38,214.07 R4LL.1
  TOP w0.254: v6(174.02,213.69) 175.42,213.69
  L3_SIGNAL w0.178: v3(169.07,211.91) 169.07,211.95 169.8,212.68 173.01,212.68 v6(174.02,213.69)
  BOTTOM w0.241: v3(169.07,211.91) 169.07,211.58 168.83,211.34 R20.1
1P5V_RAMP1: length 2.5
  TOP w0.203: U1LL.3 180.15,213.2 180.5,212.85 180.5,212.17 181.14,211.52 R9LL.1
1P5V_RAMP2: length 2.7
  TOP w0.203: R11LL.1 173.39,213.44 173.62,213.2 U1LL.26
1P5V_SW1: length 1.1
  BOTTOM w0.508: C11LL.2 178.63,214.63 v5(178.63,214.47)
1P5V_SW2: length 2.9
  TOP w0.508: 176.78,214.65 176.78,215.37 v5(176.69,215.47)
  BOTTOM w0.508: C12LL.1 175.04,214.71 175.55,215.21 176.43,215.21 v5(176.69,215.47)
  vias: v5(176.78,214.47)
3P3V: length 10
  TOP w0.508: R6NN.1 173.12,188.52 v5(173.35,188.29) ; v4(191.27,185.31) 191.84,185.88 3P3V.1
  BOTTOM w0.508: v4(191.27,185.31) 191.13,185.44 R6M.1 ; v5(173.35,188.29) 174.24,189.18 177.29,189.18 v5(177.99,189.88) R6X.1
  vias: v3(188.05,108.68) v4(188.05,113.76) v4(188.05,111.22) v4(189.32,109.95)
3P3V_BYP: length 1.5
  TOP w0.305: v3(183.41,226.4) 182.78,226.4 C14OO.1
  BOTTOM w0.305: U100.4 v3(183.41,226.4)
3P3V_HMC: length 4.2
  TOP w0.508: v5(143.89,120.47) 142.88,121.48 E1OO.1 ; E3OO.1 171.32,118.31 v6(171.57,118.57) ; v6(175.64,109.93) v6(175,109.93) E2OO.1
  vias: v4(184.05,228.04) v4(184.05,227.15) v4(184.82,230.45) v4(184.82,229.31) v6(174.37,110.44) v6(174.37,109.93) v6(174.37,109.3) v6(175,110.44) v6(175,109.3) v6(175.64,110.44) v6(175.64,109.3) v6(176.27,110.44) v6(176.27,109.93) v6(176.27,109.3)
3P3V_REG: length 2
  BOTTOM w0.305: U100.8 178.85,226.9 178.34,226.39 C5OO.1
3P3VAUX: length 30.6
  L10_SIGNAL w0.508: v4(169.44,105.03) 170.89,105.03 172.62,106.76 178.13,106.76 181.99,110.62 185.06,110.62 186.23,111.79 186.23,117.01 v2(188.05,118.84)
  BOTTOM w0.381: v4(169.44,105.03) 169.16,104.75 C1K.1 169.77,103.88 170.06,103.59 U1K.8
3P8V: length 41.2
  TOP w0.508: DS1X.A v5(144.78,229.31) ; R24LL.2 166.66,217.63 v5(167.42,218.4) ; DS1M.A v5(144.78,225.38) ; DS1NN.A v5(144.78,228.04) ; DS1Q.A v5(144.78,226.65)
  L10_SIGNAL w0.254: v5(144.78,225.38) 146.94,223.22 149.96,223.22 151.94,221.24 151.94,219.48 151.1,218.64 v2(150.62,218.64)
  BOTTOM w0.254: 184.82,204.8 184.44,204.42 184.44,199.08 185.32,198.2 186.21,198.2 R6Q.1 ; v5(189.53,196.04) 189.53,196.58 189.28,196.84 R4Q.1 189.17,196.84 188.88,196.54 188.88,196.37 ; v2(150.62,218.64) 150.1,218.13 U1.34
  BOTTOM w0.305: 186.85,197.05 187.23,196.67 188.58,196.67 188.88,196.37 v5(188.88,196.04)
  BOTTOM w0.508: R22LL.2 168.32,218.4 v5(167.42,218.4) 167.42,222.66 166.76,223.32 P1.1 ; R6Q.1 186.21,197.69 186.85,197.05 ; v5(189.53,196.04) v5(188.88,196.04)
  vias: v3(185.8,209.5) v3(185.8,208.87) v3(185.8,208.23) v3(186.56,209.5) v3(186.56,208.87) v3(186.56,208.23) v4(177.45,230.2) v4(177.45,229.44) v4(178.21,230.2) v4(178.21,229.44) v4(178.72,223.72) v5(170.97,223.62) v5(170.97,222.83) v5(171.86,223.6) v5(171.86,222.83) v5(172.75,223.6) v5(172.75,222.83) v5(174.4,225.37) v5(174.4,224.61) v5(174.4,223.6)
3P8V_BST3: length 2.5
  TOP w0.203: U1LL.13 178.45,217.88 178.96,218.39 179.23,218.39 179.57,218.73 C14LL.1
3P8V_COMP3: length 3.2
  TOP w0.241: U1LL.21 v3(174.02,215.7)
  TOP w0.279: v3(174.02,215.7) 174,215.72 C6LL.1
  BOTTOM w0.241: v3(174.02,215.7) 174,215.72 R44LL.1
3P8V_FB3: length 11.7
  TOP w0.305: v3(168.59,216.64) 169.86,216.64 170.72,217.5 173.01,217.5 174.3,216.2 U1LL.20
  TOP w0.508: v3(168.59,216.64) 167.93,215.97 167.93,215.09 R18LL.1 166.69,215.09 R24LL.1
  BOTTOM w0.241: v3(168.59,216.64) 168.44,216.79 C13LL.1
3P8V_RAMP3: length 3.3
  TOP w0.254: 173.64,218.14 174.9,216.88 U1LL.19
  TOP w0.279: R8LL.1 173.19,218.58 173.64,218.14
3P8V_RC: length 1.1
  BOTTOM w0.305: R22LL.1 C13LL.2
12P0V_1: length 27.6
  TOP w0.203: U1LL.16 176.95,217.23 176.69,217.5 v3(176.69,217.66)
  TOP w0.254: U1LL.10 180.45,217.37
  TOP w0.305: C7LL.1 183.68,216.83 R7LL.1
  TOP w0.381: v5(176.03,213.42) v5(176.03,212.37) 175.98,212.31 175.98,211.93 175.96,211.92 175.96,211.91 175.79,211.73 175.78,211.73 175.5,211.45
  TOP w0.508: TP1A.1 191.49,234.27 190.98,233.76 12P0V.1 ; D1A.C v4(163.57,234.65) ; v5(175.11,211.45) 175.5,211.45 ; v5(176.03,213.42) v5(176.03,214.47) ; 180.45,217.37 v5(180.6,217.53) ; v5(179.38,214.47) v5(179.38,213.42) v5(179.38,212.37) 179.38,211.51 v5(179.48,211.4) v5(180.24,211.4)
  TOP w0.762: C7LL.1 181.04,217.56 180.63,217.56 v5(180.6,217.53)
  BOTTOM w0.254: C13.1 v5(143.22,210.52) 143.22,210.97 U3.A1
  BOTTOM w0.508: v3(176.43,218.52) 176.69,218.26 v3(176.69,217.66) 176.92,217.89 176.92,218.73 ; v4(163.57,234.65) 163.57,231.93 ; C30LL.1 181.98,209.03 C3LL.1
  vias: v3(173.35,235.41) v3(173.35,234.65) v3(173.61,236.17) v3(174.5,236.17) v3(175.26,236.17) v3(176.15,236.17) v3(176.91,236.17) v3(176.91,235.41) v3(176.91,234.65) v3(177.67,236.17) v3(178.43,236.17) v3(187.48,229.44) v3(190.28,228.68) v4(162.56,234.65) v4(164.59,234.65) v4(189.48,104.47) v4(189.48,103.71) v4(189.48,102.95) v4(190.62,104.47) v4(190.62,103.71) v4(190.62,102.95) v5(175.16,210.64) v5(175.93,211.4) v5(175.93,210.64) v5(176.43,227.15) v5(179.48,210.64) v5(180.24,210.64) v5(190.4,227.15)
12P0V_FMC: length 3.2
  BOTTOM w0.305: P1K.C37 189.35,112.49 189.97,113.08 189.97,114.13 189.79,114.31 v4(189.79,114.43)
  BOTTOM w0.508: v4(188.77,114.4) 188.97,114.61 188.97,114.63 P1K.C35
  vias: v3(193.16,103.84)
5056_CFG1: length 3
  TOP w0.203: U1LL.28 174.34,212.2 173.29,211.15 R2LL.1
5056_CFG2: length 2.8
  TOP w0.203: U1LL.27 174.18,212.7 173.77,212.29 R12LL.1
5056_MODE: length 4.1
  TOP w0.203: U1LL.11 179.45,217.23 179.9,217.67 179.9,217.8 180.16,218.06 180.19,218.06 180.27,218.14 180.37,218.14 180.89,218.66 R14LL.2
5056_RT: length 2.4
  TOP w0.203: U1LL.6 180.24,214.7 180.5,214.96 180.5,215.49 180.75,215.74 180.93,215.93 180.93,216.15 181.13,216.36 R16LL.1
5056_VREG: length 8.6
  TOP w0.203: v3(179.36,216.1) 179.71,216.1 179.81,216.2 U1LL.9
  TOP w0.508: v4(182.53,219.91) 182.15,220.29 R14LL.1
  L10_SIGNAL w0.508: v4(182.53,219.91) 182.53,218.01 181.39,216.86 180.12,216.86 v3(179.36,216.1)
  BOTTOM w0.508: C8LL.1 182.66,219.79 v4(182.53,219.91)
A1P0V_ADJ: length 1.5
  TOP w0.254: R4NN.1 165.94,184.29 U1NN.8
A1P0V_INN: length 49.9
  TOP w0.254: U1NN.1 169.23,186.51 169.67,186.51 169.95,186.23 U1NN.16 ; v5(166.49,194.77) 166.49,190.47 166.47,190.45
  L10_SIGNAL w0.203: 148.71,219.53 148.97,219.79 149.35,219.79 149.6,220.04 v2(150.62,220.04)
  L10_SIGNAL w0.254: v5(166.49,194.77) 166.49,201.75 157.6,210.64 148.59,210.64 146.17,213.06 146.17,214.33 146.94,215.09 147.83,215.09 148.71,215.98 148.71,219.53
  BOTTOM w0.254: v2(150.62,220.04) 150.2,219.62 U1.31
  BOTTOM w0.508: C3NN.1 v4(169.1,187.4)
A1P0V_REF: length 1.6
  TOP w0.254: U1NN.5 166.51,185.79 165.94,186.36 C5NN.1
A1P0V_REG: length 1.4
  TOP w0.254: C4NN.1 166.11,185.4 166.22,185.29 U1NN.6
A1P0V_SNS: length 74.9
  L10_SIGNAL w0.203: v2(150.62,219.28) 151.38,220.04 151.38,220.68 149.48,222.58 142.87,222.58 140.08,219.79 140.08,217.25
  L10_SIGNAL w0.254: 140.08,217.25 140.08,211.41 142.87,208.61 144.9,208.61 146.49,207.02 154.37,207.02 159.36,202.03 161.64,202.03 163.32,200.36 163.32,184.1 164.59,182.83 166.11,182.83 v5(167,181.94)
  BOTTOM w0.241: v3(170.05,183.85) 170.77,184.57 R22.1
  BOTTOM w0.254: U1.32 150.47,219.13 v2(150.62,219.28)
  vias: v5(167,181.31) v5(167,180.67) v5(167.64,181.94) v5(167.64,181.31) v5(167.64,180.67)
A1P0V_SS: length 2.7
  TOP w0.203: U1NN.14 172.54,184.79 C8NN.1
A2P0V_BYP: length 3.2
  TOP w0.254: U1P.3 192.08,223.24 192.31,223.47 192.31,224.74 192.06,224.99 C4P.1
A2P0V_EN: length 2.5
  TOP w0.254: U1P.7 187.14,222.74 R2P.2 R3P.1
A2P0V_INP: length 37.3
  TOP w0.508: v4(188.12,221.35) 188.33,221.35 188.59,221.09 C2P.1
  L10_SIGNAL w0.254: v2(150.62,217.88) 165.86,217.88 168.27,220.3 177.04,220.3 178.68,221.94 v4(182.66,221.94)
  BOTTOM w0.254: U1.35 150.36,217.62 v2(150.62,217.88)
  BOTTOM w0.508: C3P.1 187.75,221.94 188.12,221.56 v4(188.12,221.35)
A2P0V_REF: length 3.3
  TOP w0.254: R5P.1 186.91,224.17 v4(186.91,223.59) 187.22,223.59 187.57,223.24 U1P.6
  BOTTOM w0.508: C7P.1 187.74,223.59 v4(186.91,223.59)
A2P0V_REG: length 1.7
  TOP w0.254: U1P.1 191.58,221.78 v5(191.8,221.56)
  BOTTOM w0.508: C5P.1 v5(191.8,221.56)
A2P0V_SNS: length 3.2
  TOP w0.254: R6P.1 188.47,225.16 U1P.5
  TOP w0.508: R6P.1 187.11,225.5 R5P.2
AD7175_CS: length 144.4
  TOP w0.241: U2FF.3 165.46,141.47 v3(164.98,141.94)
  L3_SIGNAL w0.178: 138.3,146.76 140.52,146.76 142.75,144.53 v3(142.75,144.48) ; 140.14,219.97 133.34,226.77 128.39,226.77 127.63,226.01 127.63,224.87 126.74,223.98 126.74,220.93 127.51,220.17 127.51,208.67 136.9,199.27 136.9,190.58 136.14,189.82 136.14,175.85 133.22,172.92 133.22,152.35
  L3_SIGNAL w0.203: 140.14,219.97 140.19,219.91 141.98,219.91 142.62,219.28 v5(142.62,218.39) ; 133.22,152.35 133.22,151.59 135.63,149.18 135.63,148.54 137.41,146.76 138.3,146.76
  L10_SIGNAL w0.178: v3(142.75,144.48) 143.19,144.03 143.19,141.11 143.89,140.41 151.51,140.41 153.67,138.25 159.38,138.25 163.07,141.94 v3(164.98,141.94)
  BOTTOM w0.254: U1.17 142.88,218.13 v5(142.62,218.39)
AD7175_DIN: length 140.2
  TOP w0.241: v3(163.95,149.43) 164.84,148.54 R12.2
  L3_SIGNAL w0.178: 141.15,217.32 138.11,217.32 135.32,220.1 135.32,223.4 132.9,225.82 130.24,225.82 128.78,224.36 128.78,222.45 130.05,221.18 130.05,211.66 129.54,211.15 129.54,207.98 137.85,199.66 137.85,192.68 138.43,192.1 138.43,190.88 137.79,190.25 137.79,189.43 137.16,188.8 137.16,188.04 137.73,187.47 137.73,175.14 134.87,172.29 134.87,154.13 ; v3(143.51,145.87) 142.75,145.87 140.46,148.16
  L3_SIGNAL w0.203: 141.15,217.32 141.34,217.13 v5(142.88,217.13) ; 134.87,154.13 134.87,151.84 136.78,149.94 136.78,149.43 138.05,148.16 140.46,148.16
  L10_SIGNAL w0.178: v3(163.95,149.43) 161.29,149.43 160.14,148.29 159,148.29 158.24,147.52 158.24,146.38 157.73,145.87 156.72,145.87 152.4,141.56 145.59,141.56 145.41,141.73 145.41,143.97 v3(143.51,145.87)
  BOTTOM w0.254: U1.15 v5(142.88,217.13)
AD7175_DOUT: length 141.1
  TOP w0.241: R11.2 164.59,149.68 164.97,149.3 v3(165.99,149.3) 166.7,148.59 U1FF.4
  L3_SIGNAL w0.178: v3(143,146.76) 142.49,146.76 140.08,149.18 ; 136.4,153.62 136.4,170.77 138.17,172.54 138.17,186.13 139.19,187.15 139.19,188.67 139.7,189.18 139.7,191.47 138.3,192.86 138.3,199.85 130.81,207.34 130.81,209.63 131.19,210.01 131.19,210.77 130.55,211.41 130.55,221.44 129.16,222.84 129.16,224.11 130.43,225.38 132.71,225.38 134.87,223.22 134.87,219.91 137.92,216.87 139.82,216.87 140.27,216.42
  L3_SIGNAL w0.203: 136.4,153.62 136.4,152.35 137.79,150.95 137.79,150.7 139.06,149.43 139.82,149.43 140.08,149.18 ; 140.27,216.42 140.59,216.11 v5(141.73,216.11)
  L10_SIGNAL w0.178: v3(143,146.76) 143,145.62 144.52,144.1 144.52,141.61 144.96,141.17 152.78,141.17 156.46,144.86 158.11,144.86 158.87,145.62 158.87,146.51 161.16,148.79 163.95,148.79 164.46,149.3 v3(165.99,149.3)
  BOTTOM w0.254: R3.2 v5(141.73,216.11)
AD7175_SCLK: length 139.5
  TOP w0.241: R13.2 161.54,147.78 v3(161.29,148.03)
  L3_SIGNAL w0.178: 137.79,218.26 135.77,220.29 135.77,223.59 133.08,226.27 128.91,226.27 128.14,225.5 128.14,224.61 127.63,224.11 127.63,220.93 128.39,220.17 128.39,208.49 137.4,199.48 137.4,192.49 137.92,191.97 137.92,191.35 137.28,190.7 137.28,189.93 136.52,189.18 136.52,187.52 137.28,186.77 137.28,175.84 134.11,172.67 134.11,155.02 ; v3(143,144.98) 143,144.99 140.71,147.27
  L3_SIGNAL w0.203: 137.79,218.26 138.05,218.01 v5(141.86,218.01) ; 134.11,155.02 134.11,151.33 136.01,149.43 136.01,148.79 137.28,147.52 140.46,147.52 140.71,147.27
  L10_SIGNAL w0.178: v3(143,144.98) 144.02,143.97 144.02,141.3 144.52,140.79 152.91,140.79 155.95,143.84 157.73,143.84 160.65,146.76 160.65,147.4 v3(161.29,148.03)
  BOTTOM w0.254: U1.16 143.1,217.62 143.09,217.63 142.61,217.63 142.24,218.01 v5(141.86,218.01)
ADC0: length 4.3
  BOTTOM w0.279: ADC0.1 C3S.2
ADC1: length 4.4
  BOTTOM w0.279: ADC1.1 125.16,127.4 125.16,127.41 arc(125.16,127.41) C3T.2
ADC2: length 4.3
  TOP w0.279: ADC2.1 C3U.2
ADC3: length 4.3
  TOP w0.279: ADC3.1 C3V.2
ADC_CLK: length 3.6
  TOP w0.279: C3R.2 152.5,194.54 ADC_CLK.1
ADC_N0: length 1.7
  BOTTOM w0.254: v7(155.39,175.95) 155.19,176.78 C1S.1
ADC_N1: length 1.9
  BOTTOM w0.254: v7(155.39,162.35) 155.16,161.23 155.17,161.22 C2T.1
ADC_N2: length 1.9
  TOP w0.254: C2U.1 158.37,176.61 158.61,176.37 U1AA.A9
ADC_N3: length 1.9
  TOP w0.254: U1AA.V10 159.41,161.86 159.64,161.62 C2V.1
ADC_P0: length 1.7
  BOTTOM w0.254: C2S.1 156.46,177.09 156.46,176.84 v7(156.22,175.95)
ADC_P1: length 1.9
  BOTTOM w0.254: v7(156.22,162.35) 156.44,161.23 C1T.1
ADC_P2: length 1.9
  TOP w0.254: U1AA.A10 159.41,176.37 159.64,176.61 C1U.1
ADC_P3: length 1.9
  TOP w0.254: C1V.1 158.37,161.69 158.61,161.92 U1AA.V9
ADCDRV_N: length 11.5
  TOP w0.102: v3(151.51,184.1) 151.23,184.38 C1R.1
  L10_SIGNAL w0.133: v1(153.81,174.35) 153.81,174.55 154.05,174.79 154.05,176.3 153.08,177.28 153.08,181.77 151.63,183.22 151.63,183.98 v3(151.51,184.1)
ADCDRV_P: length 11.6
  TOP w0.102: v3(152.07,184.1) 152.07,184.16 C2R.1
  L10_SIGNAL w0.133: v1(154.61,174.35) 154.61,174.53 154.31,174.82 154.31,176.41 153.34,177.38 153.34,181.88 151.89,183.33 151.89,183.92 v3(152.07,184.1)
AGC0_0: length 82.6
  TOP w0.241: AGC.5 v6(155.83,103.96) ; v3(158.87,130.76) 158.8,130.69 158.8,129.39 158.87,129.32 158.87,126.06 v3(159.26,125.68) 159.98,124.96 U4FF.3
  L3_SIGNAL w0.127: 161.4,173.16 161.4,161.53
  L3_SIGNAL w0.178: v3(154.81,119.46) 154.81,114.29 155.19,113.91 155.19,112.02 154.75,111.58 154.75,107.33 155.83,106.25 155.83,103.96 v6(155.83,103.96) ; v3(158.87,130.76) 159.89,131.78 159.89,141.56 159.59,141.86 159.59,143.77 159.38,143.97 158.72,143.97 158.42,144.27 158.42,152.07 157.88,152.6 157.02,152.6 156.46,153.16 156.46,157.3 158.61,159.45 159.32,159.45 161.4,161.53 ; v1(161.01,173.55) 161.4,173.16
  L10_SIGNAL w0.178: v3(159.26,125.68) 160.02,124.92 160.02,122.89 158.76,121.63 156.98,121.63 v3(154.81,119.46)
AGC0_1: length 95.2
  TOP w0.241: v3(159.38,124.66) 159.59,124.46 U4FF.4 ; AGC.6 155.83,109.3 157.1,110.57 v6(157.1,111.58)
  L3_SIGNAL w0.178: v3(154.3,126.32) 152.78,127.84 149.48,127.84 147.38,129.94 147.38,135.14 147.95,135.71 147.95,150.95 144.78,154.13 144.78,155.02 143.79,156.01 143.79,157.96 143.89,158.07 143.89,158.57 143.81,158.65 143.81,158.66 143.67,158.8 143.67,159.06 143.81,159.2 143.81,162.43 147.44,166.07 148.9,166.07 149.98,167.15 149.98,167.71 150.38,168.11 150.38,170.23 150.24,170.37 150.24,172.03 152.15,173.94 159.81,173.94 v1(160.21,173.55) ; v6(157.1,111.58) 156.41,112.27 156.41,118.39 159.38,121.36 159.38,122.38 160.02,123.01 160.02,124.03 v3(159.38,124.66)
  L10_SIGNAL w0.178: v3(154.3,126.32) 155.6,126.32 157.48,124.44 159.15,124.44 v3(159.38,124.66)
AGC1_0: length 94
  TOP w0.241: U4FF.5 v6(159.13,123.96) ; AGC.7 v6(157.1,103.96)
  L3_SIGNAL w0.178: v1(161.01,172.75) 160.6,172.34 153.75,172.34 153.39,171.98 153.39,170.28 152.98,169.88 152.04,169.88 150.95,168.78 150.95,167.8 150.54,167.39 150.54,166.92 148.29,164.67 147.83,164.67 144.52,161.37 144.52,159.44 144.9,159.06 144.9,158.19 148.77,154.33 148.77,131.15 151.25,128.67 153.48,128.67 156.09,126.06 157.02,126.06 v6(159.13,123.96) 159.16,123.96 159.55,123.57 159.55,123.05 155.75,119.25 155.75,111.13 157.52,109.36 157.52,104.38 v6(157.1,103.96)
AGC1_1: length 90.8
  TOP w0.241: AGC.8 v3(157.1,107.95) ; U4FF.6 160.08,123.46 160.02,123.39 v6(159.13,123.39)
  L3_SIGNAL w0.178: v3(157.1,107.95) 155.32,109.73 155.32,111.76 155.47,111.91 155.47,114.03 155.32,114.18 155.32,119.58 v6(159.13,123.39) 159.1,123.39 156.81,125.68 155.53,125.68 152.83,128.39 151.13,128.39 148.3,131.22 148.3,151.12 145.54,153.87 145.54,155.4 144.22,156.72 144.22,157.76 144.52,158.07 144.52,158.95 144.14,159.34 144.14,161.75 147.83,165.43 148.66,165.43 150.26,167.03 150.26,167.59 150.66,167.99 150.66,170.34 150.57,170.43 150.57,171.55 152.14,173.12 159.84,173.12 v1(160.21,172.75)
AGC2_0: length 93.6
  TOP w0.241: U5FF.3 166.76,124.96 v3(166.37,125.35) ; AGC.9 v6(158.37,103.96)
  L3_SIGNAL w0.178: v6(158.37,103.96) 160.86,106.45 161.69,106.45 165.86,110.62 165.86,118.95 165.39,119.42 165.39,120.51 165.61,120.73 165.61,123.14 165.95,123.49 165.95,124.63 166.37,125.05 v3(166.37,125.35) ; v3(156.59,128.09) 156.59,128.27 154,130.86 154,134.98 151.51,137.47 151.51,157.53 151.94,157.96 151.94,161.6 151.51,162.03 151.51,164.67 152.02,165.18 153.17,165.18 153.39,165.39 153.39,165.74 153.59,165.94 153.92,165.94 154.18,166.19 154.18,167.34 154.35,167.51 154.62,167.51 154.94,167.84 154.94,168.88 155.2,169.14 155.56,169.14 155.78,169.36 155.78,169.7 156,169.93 159.51,169.93 159.77,170.18 159.77,170.44 160.07,170.74 160.35,170.74 160.6,170.99 160.6,171.54 v1(161.01,171.95)
  L10_SIGNAL w0.178: v3(156.59,128.09) 156.59,128.6 157.11,129.12 162.06,129.12 164.08,127.1 164.62,127.1 v3(166.37,125.35)
AGC2_1: length 97.4
  TOP w0.241: U5FF.4 166.37,124.46 v3(165.48,125.35) ; AGC.10 v3(158.37,107.95)
  L3_SIGNAL w0.178: v1(160.21,171.95) 159.83,171.58 154.58,171.58 154.24,171.23 154.24,170.33 153.86,169.95 153.76,169.95 153.42,169.61 153.42,169.51 153.07,169.16 151.91,169.16 151.25,168.51 151.25,167.62 150.9,167.26 150.9,166.78 148.28,164.16 147.95,164.16 144.83,161.04 144.83,159.59 145.21,159.21 145.21,158.4 149.17,154.43 149.17,132.23 151.85,129.55 153.22,129.55 155.95,126.82 v3(156.46,126.82) ; v3(158.37,107.95) 159.46,109.04 160.02,109.04 164.97,114 164.97,118.44 164.73,118.68 164.73,120.79 164.89,120.95 164.89,122.25 164.73,122.42 164.73,124.68 165.4,125.35 v3(165.48,125.35)
  L10_SIGNAL w0.178: v3(156.46,126.82) 156.46,127.12 157.01,127.67 157.01,128.13 157.6,128.73 161.75,128.73 164.23,126.24 164.59,126.24 v3(165.48,125.35)
AGC3_0: length 89
  TOP w0.241: AGC.11 v6(159.64,103.96) ; U5FF.5 v3(166.37,123.96)
  L3_SIGNAL w0.178: v1(161.01,171.15) 161.01,170.8 160.63,170.42 160.63,169.52 160.26,169.16 156.17,169.16 155.83,168.82 155.83,167.92 155.42,167.51 155.32,167.51 154.94,167.13 154.94,165.44 154.68,165.18 153.78,165.18 153.42,164.81 153.42,164.71 153.12,164.42 153.02,164.42 151.89,163.28 151.89,162.16 152.6,161.44 152.6,157.63 151.89,156.92 151.89,137.72 154.48,135.13 154.48,130.84 v3(157.48,127.84) ; v3(166.37,123.96) 166.37,123.27 165.99,122.89 165.99,122.36 166.37,121.98 166.37,110.19 162.02,105.84 161.52,105.84 v6(159.64,103.96)
  L10_SIGNAL w0.178: v3(166.37,123.96) 166.07,123.96 165.74,124.28 165.35,124.28 165.32,124.32 165.32,124.32 164.56,125.07 163.85,125.07 161.09,127.84 v3(157.48,127.84)
AGC3_1: length 87.9
  TOP w0.241: U5FF.6 165.98,123.46 165.66,123.78 v3(165.48,123.78) ; AGC.12 v3(159.64,107.95)
  L3_SIGNAL w0.178: v1(160.21,171.15) 159.97,171.15 159.56,170.74 155.35,170.74 154.96,170.36 154.96,169.46 154.67,169.17 154.57,169.17 154.12,168.72 154.12,168.62 153.91,168.4 151.89,168.4 151.59,168.1 151.59,167.51 151.18,167.11 151.18,166.66 150.96,166.45 150.96,162.09 151.59,161.47 151.59,158.29 150.54,157.25 150.54,136.3 150.24,136 150.24,131.95 152.31,129.87 154.05,129.87 157.1,126.82 v3(157.48,126.82) ; v3(165.48,123.78) 165.48,123.52 165.22,123.27 165.22,120.81 165.06,120.65 165.06,118.99 165.45,118.59 165.45,113.76 v3(159.64,107.95)
  L10_SIGNAL w0.178: v3(165.48,123.78) 165.28,123.78 164.44,124.61 162.46,124.61 160.25,126.82 v3(157.48,126.82)
AIN1: length 54.3
  L10_SIGNAL w0.254: v4(185.54,189.31) 181.23,193.63 181.23,195.28 179.83,196.67 177.09,196.67 175.26,198.5 175.26,203.79 173.23,205.82 169.11,205.82 159.84,215.09 149.98,215.09 v2(148.08,213.18)
  BOTTOM w0.254: U1.3 147.81,213.46 v2(148.08,213.18)
  vias: v4(186.31,189.31) v4(187.07,189.31) v4(187.83,189.31)
AIN2: length 57.5
  TOP w0.254: v4(186.56,184.48) 186.59,184.51 U1M.10
  L10_SIGNAL w0.254: v4(185.8,184.48) 181.89,188.39 181.89,190.83 174.37,198.35 174.37,203.28 172.92,204.73 167.46,204.73 160.27,211.91 152.65,211.91 151.13,213.44 149.73,213.44 148.84,212.55 147.95,212.55 147.31,213.2 v2(147.31,213.69)
  BOTTOM w0.254: U1.4 v2(147.31,213.69)
  vias: v4(187.32,184.48) v4(188.08,184.48)
AIN5: length 70.8
  TOP w0.241: U1X.16 175.51,184.31 v4(175.51,184.3)
  TOP w0.254: 175.77,188.44 174.65,188.44 v3(174.62,188.42)
  TOP w0.508: U1X.4 U1X.3 U1X.2 U1X.1 175.97,183.92 175.56,184.33
  L10_SIGNAL w0.203: v2(146.94,221.44) 146.3,222.07 143.38,222.07
  L10_SIGNAL w0.254: v3(174.62,188.42) 172.46,190.58 166.88,190.58 164.11,193.35 164.11,200.59 161.92,202.77 159.89,202.77 154.94,207.72 147.06,207.72 145.41,209.37 143.13,209.37 140.97,211.53 140.97,219.66 143.38,222.07
  BOTTOM w0.241: v2(146.94,221.44) 147.31,221.07 U1.27
  BOTTOM w0.508: C1X.1 174.56,184.3 v4(175.51,184.3) C2XA.1
AIN6: length 67.5
  L10_SIGNAL w0.203: v2(147.7,221.44) 147.06,220.8 145.67,220.8 144.14,219.28
  L10_SIGNAL w0.254: v5(179.83,183.75) 179.83,186.64 178.69,187.78 178.69,191.97 177.04,193.63 166.37,193.63 165.1,194.9 165.1,200.99 162.18,203.91 161.29,203.91 156.08,209.12 147.95,209.12 144.14,212.93 144.14,219.28
  BOTTOM w0.241: v2(147.7,221.44) 147.81,221.33 U1.28
  vias: v5(178.99,184.43) v5(179.83,182.93) v5(179.83,182.09)
AIN14: length 113.5
  TOP w0.241: 193.29,215.09 193.29,214.58 192.91,214.2 v3(191.64,214.2) 190.88,213.44 v3(188.72,213.44)
  L5_POWER_ANALOG w0.635: 167.69,169.42 171.4,173.13 171.4,176.51 171.78,176.89 172.11,176.89 172.41,177.19 172.41,178.18 173,178.77 173.86,178.77 175.13,180.04 180.95,180.04 184.53,183.62 184.53,190.55 184.86,190.88 184.86,195.1 185.66,195.9 v5(186.7,195.9)
  L10_SIGNAL w0.178: v5(186.7,195.9) 188.74,197.94 190.24,197.94 191.51,199.21 191.51,209.75 191.64,209.88 v3(191.64,214.2)
  L10_SIGNAL w0.254: v2(150.62,217.13) 159.12,217.13 164.97,211.28 168.3,211.28 173.23,206.35 179.93,206.35 187.02,213.44 v3(188.72,213.44)
  BOTTOM w0.241: C6P.1 v5(186.7,195.9)
  BOTTOM w0.254: U1.36 v2(150.62,217.13)
  vias: v1(163.41,168.75)
BVDD2: length 29.3
  TOP w0.241: E2.2 v3(190.78,218.62)
  L10_SIGNAL w0.178: v5(184.02,195.16) 187.31,198.45 189.86,198.45 191.13,199.72 191.13,208.38 190.37,209.15 190.37,218.22 v3(190.78,218.62)
  vias: v1(157.01,173.55) v1(157.01,172.75) v1(157.01,165.55) v1(157.01,164.75) v1(160.21,175.15) v1(160.21,163.15) v5(183,195.15) v5(183,194.26) v5(183.51,194.64) v5(183.51,193.63) v5(184.02,194.26)
BVDD3_0:
  vias: v1(159.41,174.35)
BVDD3_1:
  vias: v1(159.41,163.95)
BVNN1_0: length 3.2
  TOP w0.241: v1(157.81,173.55) v1(157.81,172.75) U1AA.E9 U1AA.E10
  BOTTOM w0.241: v1(157.81,173.55) v1(157.81,172.75)
BVNN1_1: length 3.2
  TOP w0.241: v1(157.81,164.75) v1(157.81,165.55) U1AA.P9 U1AA.P10
  BOTTOM w0.241: v1(157.81,164.75) v1(157.81,165.55)
BVNN2_0:
  vias: v1(158.61,174.35)
BVNN2_1:
  vias: v1(158.61,163.95)
CLKIN_N: length 3.8
  TOP w0.254: U1AA.K1 150.66,168.53 C5D.2
CLKIN_P: length 3.8
  TOP w0.254: U1AA.J1 150.66,169.79 C3D.2
CLKOUT_0_N: length 76.3
  L10_SIGNAL w0.133: v1(157.96,139.52) 157.78,139.7 arc(157.74,139.76) 157.73,139.82 157.73,141.88 arc(157.74,141.94) 157.78,142 161.03,145.25 arc(161.15,145.33) 161.3,145.36 165.41,145.36 arc(165.93,145.46) 166.36,145.75 171.51,150.9 arc(172.69,151.69) 174.08,151.96 177.94,151.96 arc(178.63,152.2) 179.03,152.8 arc(179.44,153.4) 180.13,153.63 arc(180.17,153.63) 180.22,153.62 arc(180.37,153.51) 180.43,153.33 v2(180.43,153.13)
  BOTTOM w0.102: C30B.2 138.64,107.65 137.67,107.65 137.16,108.15 137.16,122.63 141.5,126.98 148.28,126.98 157.72,136.41 157.72,139.28 v1(157.96,139.52)
CLKOUT_0_P: length 77.4
  L10_SIGNAL w0.133: v1(157.25,139.52) 157.42,139.7 arc(157.46,139.76) 157.47,139.82 157.47,141.88 arc(157.5,142.04) 157.6,142.18 160.84,145.43 arc(161.05,145.57) 161.3,145.62 165.41,145.62 arc(165.83,145.7) 166.18,145.94 171.32,151.08 arc(172.59,151.93) 174.08,152.22 177.94,152.22 arc(178.47,152.4) 178.78,152.87 arc(178.81,152.98) 178.81,153.1 178.81,153.23 arc(179.01,153.7) 179.47,153.89 180.13,153.89 arc(180.21,153.88) 180.29,153.87 180.3,153.89 180.39,153.98 arc(180.42,154.03) 180.43,154.08 v2(180.43,154.4)
  BOTTOM w0.102: C29B.2 138.69,107.42 137.57,107.42 136.93,108.06 136.93,122.73 141.41,127.2 148.19,127.2 157.49,136.51 157.49,139.28 v1(157.25,139.52)
CLKOUT_6_N: length 71.7
  L3_SIGNAL w0.133: v1(178.15,155.23) 178.23,155.23 178.27,155.27 arc(178.32,155.3) 178.38,155.32 179.32,155.32 arc(179.48,155.35) 179.62,155.44 180.35,156.17 184.11,156.17 184.24,156.04 v5(184.24,155.67) ; v3(148.37,122.12) 148.14,122.35 148.14,126.25 146.31,128.09 146.31,140.19 146.94,140.82 146.94,142.33 v3(147.16,142.55)
  L10_SIGNAL w0.133: v1(178.15,155.23) 178.03,155.31 arc(177.97,155.33) 177.91,155.34 161.87,155.34 158.62,152.1 149.86,152.1 146.94,149.18 146.94,142.77 v3(147.16,142.55)
  BOTTOM w0.102: C32B.2 148.39,120.09 148.13,120.36 148.13,121.88 v3(148.37,122.12)
CLKOUT_6_P: length 72.2
  L3_SIGNAL w0.133: v1(178.15,155.74) 178.26,155.63 arc(178.32,155.59) 178.38,155.58 179.32,155.58 arc(179.38,155.59) 179.44,155.63 180.24,156.43 184.11,156.43 184.24,156.56 v5(184.24,156.94) ; v3(146.41,142.55) 146.68,142.28 146.68,140.93 146.05,140.3 146.05,127.98 147.88,126.15 147.88,122.35 v3(147.65,122.12)
  L10_SIGNAL w0.133: v3(146.41,142.55) 146.68,142.82 146.68,149.28 149.75,152.36 158.51,152.36 161.76,155.6 177.85,155.6 arc(177.93,155.61) 178,155.63 178.13,155.71 v1(178.15,155.74)
  BOTTOM w0.102: C31B.2 147.63,120.09 147.9,120.36 147.9,121.88 v3(147.65,122.12)
CLKOUT_8_N: length 64.8
  L10_SIGNAL w0.133: v2(177.08,118.03) 176.85,117.8 176.85,115.52 arc(176.82,115.36) 176.72,115.22 174.53,113.02 arc(174.39,112.93) 174.22,112.9 168.87,112.9 arc(168.81,112.89) 168.75,112.85 162.8,106.9 arc(162.13,106.45) 161.34,106.29 155.79,106.29 arc(155.72,106.28) 155.67,106.24 153.5,104.07 arc(153.36,103.98) 153.19,103.95 150.28,103.95 149.98,104.24 149.98,104.73 v2(149.66,105.05)
  BOTTOM w0.102: P1K.B21 190.59,133.25 190.49,133.35 190.18,133.35 190.07,133.25 190.07,119.7 189.73,119.35 177.06,119.35 176.83,119.13 176.83,118.29 v2(177.08,118.03)
  BOTTOM w0.241: C34B.2 v2(149.66,105.05)
CLKOUT_8_P: length 64.3
  L10_SIGNAL w0.133: v2(176.35,118.03) 176.59,117.8 176.59,115.52 arc(176.57,115.46) 176.54,115.4 174.34,113.21 arc(174.29,113.17) 174.22,113.16 168.87,113.16 arc(168.71,113.13) 168.57,113.03 162.62,107.09 arc(162.03,106.69) 161.34,106.55 155.79,106.55 arc(155.62,106.52) 155.49,106.43 153.31,104.26 arc(153.26,104.22) 153.19,104.21 150.39,104.21 150.25,104.35 150.25,104.87 v2(150.43,105.05)
  BOTTOM w0.102: P1K.B20 190.59,133.68 190.49,133.58 190.08,133.58 189.85,133.34 189.85,119.8 189.63,119.58 176.96,119.58 176.6,119.22 176.6,118.29 v2(176.35,118.03)
  BOTTOM w0.241: C33B.2 v2(150.43,105.05)
CLKOUT_10_N: length 87.2
  L10_SIGNAL w0.133: v2(147.12,105.04) 147.12,105.46 147.37,105.71 147.37,106.15 147.66,106.44 148.43,106.44 arc(148.59,106.4) 148.73,106.31 148.84,106.2 arc(148.94,106.06) 148.97,105.89 148.97,103.95 149.64,103.28 arc(149.7,103.24) 149.76,103.23 155.34,103.23 arc(155.48,103.25) 155.61,103.3 155.67,103.34 155.71,103.38 arc(155.71,103.38) 155.72,103.39 155.72,103.39 157.68,105.34 arc(157.82,105.44) 157.98,105.47 162.89,105.47 arc(163.68,105.63) 164.35,106.08 168.98,110.7 arc(169.12,110.8) 169.28,110.83 176.32,110.83 arc(176.39,110.84) 176.44,110.88 182.07,116.5 arc(182.23,116.75) 182.29,117.05 182.29,119.18 arc(182.33,119.34) 182.42,119.48 189.99,127.05 189.99,141.92 189.72,142.18 186.44,142.18 186.05,142.58 186.05,150.08 185.04,151.09 184.38,151.09 184.24,150.96 v2(184.24,150.59)
  BOTTOM w0.241: C36B.2 v2(147.12,105.04)
CLKOUT_10_P: length 87.6
  L10_SIGNAL w0.133: v2(147.89,105.04) 147.89,105.46 147.63,105.71 147.63,106.04 147.77,106.17 148.43,106.17 arc(148.49,106.16) 148.55,106.13 148.66,106.01 arc(148.7,105.96) 148.71,105.89 148.71,103.84 149.46,103.09 arc(149.6,103) 149.76,102.97 155.34,102.97 arc(155.55,102.99) 155.74,103.07 155.78,103.07 155.89,103.19 arc(155.9,103.19) 155.9,103.2 arc(155.91,103.2) 155.91,103.21 157.86,105.16 arc(157.92,105.2) 157.98,105.21 162.89,105.21 arc(163.78,105.39) 164.54,105.89 169.16,110.52 arc(169.22,110.56) 169.28,110.57 176.32,110.57 arc(176.49,110.6) 176.63,110.69 182.25,116.32 arc(182.48,116.65) 182.55,117.05 182.55,119.18 arc(182.57,119.24) 182.6,119.3 190.25,126.94 190.25,142.03 189.83,142.44 186.55,142.44 186.31,142.69 186.31,150.19 185.15,151.35 184.38,151.35 184.24,151.48 v2(184.24,151.86)
  BOTTOM w0.241: C35B.2 v2(147.89,105.04)
CLKVDD1: length 1.5
  TOP w0.508: C6NN.1 169.8,180.28 E1NN.2
  BOTTOM w0.508: v1(156.21,171.15) 156.21,171.26 C39AA.1
  vias: v1(156.21,167.15) v5(169.54,178.64) v5(169.54,177.88) v5(170.18,179.02) v5(170.18,178.26)
D1P0V:
  vias: v1(164.21,175.95) v1(164.21,175.15) v1(164.21,174.35) v1(164.21,173.55) v1(164.21,172.75) v1(164.21,171.95) v1(164.21,171.15) v1(164.21,170.35) v1(164.21,169.55) v1(164.21,168.75) v1(164.21,167.15) v1(164.21,166.35) v1(164.21,165.55) v1(164.21,164.75) v1(164.21,163.95) v1(164.21,163.15) v1(164.21,162.35) v4(186.43,176.61) v4(186.43,175.72) v4(187.07,176.61) v4(187.07,175.72)
D1P0V_ADJ: length 1.8
  TOP w0.305: U1X.8 179.06,180.46 R4X.1
D1P0V_REF: length 2
  TOP w0.203: U1X.5 176.29,181.31 v4(175.93,180.95)
  BOTTOM w0.508: C5X.1 176.22,181.24 v4(175.93,180.95)
D1P0V_REG: length 1.9
  TOP w0.305: U1X.6 177.22,180.99 176.85,180.62 176.76,180.62 176.61,180.47 176.61,180.47 176.18,180.04 C4X.1
D1P0V_SNS: length 2.8
  TOP w0.305: R5X.2 180.29,185.74 179.51,184.96 178.77,184.96 178.22,184.41 U1X.13
D1P0V_SS: length 2.1
  TOP w0.203: C6X.1 179.06,185.75 178.29,184.99 178.05,184.99 177.72,184.66 U1X.14
D1P8V: length 78.3
  TOP w0.203: C19FF.1 147.83,102.36 147.61,102.58 U10FF.1 ; U8FF.1 170.37,114.9 170.71,114.55 170.71,113.56 C17FF.1 ; v5(172.21,150.32) 171.19,150.32 170.46,149.59 U1FF.15 ; U5FF.15 170.29,125.46 v1(170.81,125.98) ; v6(170.43,138.76) 170.48,138.81 170.48,139.27 170.29,139.47 U2FF.10 ; U6FF.1 154.55,114.9 154.68,114.76 154.68,114.5 ; v5(162.05,114.12) 161.94,114.23 U7FF.1 ; 170.45,142.01 170.41,141.97 U2FF.15 ; 168.23,143.28 168.18,143.23 167.99,143.23 ; U5FF.7 166.82,122.96 v1(166.37,122.51) ; C4FF.1 168.27,151.46 ; 168.27,150.83 168.27,150.27 U1FF.1 ; v1(164.34,122.43) 163.81,122.96 U4FF.10 ; U4FF.15 163.91,125.46 164.06,125.6 164.18,125.6 v1(164.23,125.66) ; U5FF.2 166.9,125.46 v1(166.37,125.98) ; v1(170.81,122.43) 170.29,122.96 U5FF.10
  TOP w0.254: 168.23,143.28 168.41,143.1 U2FF.1 ; U4FF.7 160.85,122.96 160.53,122.63 v4(160.53,121.87) ; v4(160.53,125.81) 160.88,125.46 U4FF.2
  TOP w0.279: R5.1 163.92,159.69 163.91,159.69 ; 163.91,158.22 163.92,158.23 R4.1
  TOP w0.305: U4FF.1 162.06,127.24 C10FF.1 ; 167.61,135.31 v4(167.46,135.31) ; U5FF.1 168.41,127.24 v1(168.27,127.38) ; U3FF.1 168.41,134.51
  TOP w0.381: v3(172.21,143.33) 171.78,143.33 170.45,142.01 ; 168.41,134.51 167.61,135.31 ; 168.27,151.46 168.27,150.83
  TOP w0.508: R14FF.2 167.52,119.51 v4(167.39,119.38) ; v4(153.29,101.93) AGC.1 AGC.2 ; v5(162.05,114.12) 162.43,113.74 C16FF.1 162.31,113.41 R18FF.2 ; C5FF.1 168.19,143.43 167.79,143.03 166.42,143.03 166.01,143.44 v3(165.15,143.44) ; v4(154.56,101.93) AGC.3 AGC.4 ; R6FF.2 v1(170.55,129.91) ; 163.91,158.22 164.32,158.22 v3(164.85,158.75) ; v4(165.61,101.93) GPIO.1 GPIO.2 ; C17FF.1 v5(170.89,113.53) ; v5(167.64,152.73) 168.27,152.1 C4FF.1 ; R11FF.1 v3(162.77,140.76) ; R33FF.2 147.85,101.37 v4(147.9,101.32) ; v3(164.34,159.26) 163.91,159.69 ; R12FF.2 v4(160.7,120.9) ; C6FF.1 167.46,135.31 arc(167.46,135.31) v4(167.46,135.31) ; 154.68,114.5 154.68,113.66 C15FF.1 v1(154.26,113.53) 154.14,113.41 R16FF.2 ; C10FF.1 v4(161.92,127.81) ; R20FF.2 v5(169.54,113.99) ; R4FF.2 v4(163.83,137.36) ; C19FF.1 148.85,102.23 v4(148.85,101.7)
  L3_SIGNAL w0.203: v1(161.81,163.95) 162.18,163.58 162.18,161.72
  L3_SIGNAL w0.508: v4(167.46,135.31) 170.43,138.28 v6(170.43,138.76) ; 162.18,161.72 162.71,161.19 162.71,158.5 163.43,157.78 v5(163.43,154.15)
  BOTTOM w0.203: C72AA.1 161.93,174.48 v1(161.81,174.35) ; v1(161.81,163.95) 161.95,163.8 C71AA.1
  BOTTOM w0.254: U1.20 v5(142.87,219.62) 142.85,219.6 C9.1
  vias: v1(158.61,171.95) v1(159.41,171.15) v3(164.97,144.86) v4(189.52,206.45) v4(189.52,204.8) v4(190.4,204.8) v4(190.53,206.45) v5(155.45,214.07) v5(155.45,213.44) v5(155.45,212.8) v5(161.42,179.16)
D1P8V_EN: length 5
  BOTTOM w0.241: R7Q.1 R6Q.2 185.77,199.65 185.77,202.48 185.94,202.65 U1Q.5
D1P8V_FB: length 5
  BOTTOM w0.305: U1Q.2 189.9,203.65 ; 189.9,203.65 190.15,203.4 190.15,201.76 R10Q.1 ; 189.9,203.65 190.87,203.65 R9Q.2
D1P8V_PG: length 10.8
  L10_SIGNAL w0.508: v3(185.07,203.4) 185.07,201.88 187.52,199.43 v3(189.64,199.43)
  BOTTOM w0.254: U1Q.7 185.32,203.65 v3(185.07,203.4)
  BOTTOM w0.508: Q1Q.1 190.76,198.71 190.36,198.71 v3(189.64,199.43) R4Q.2
DAC0: length 3.7
  TOP w0.279: DAC0.1 C2W.2
DAC3: length 3.7
  TOP w0.279: DAC3.1 120.77,140.9 124.27,140.9 arc(124.36,140.9) 124.46,140.9 124.45,140.9 C2Z.2
DAC_N0: length 4.6
  TOP w0.279: R1W.2 150.7,174.94
  TOP w0.635: U1AA.C1 151.86,174.39 arc(151.77,174.41) 151.69,174.44 151.37,174.58 arc(151.26,174.63) 151.15,174.7 arc(151.02,174.79) 150.89,174.86 arc(150.8,174.9) 150.7,174.94
  TOP w0.762: 150.7,174.94 arc(150.62,174.96) 150.53,174.98 arc(150.41,175.01) 150.28,175.05 arc(149.94,175.22) 149.64,175.46 arc(149.19,175.9) 148.71,176.31
DAC_N1: length 3.7
  BOTTOM w0.127: 151.71,172.11 151.62,172.02 arc(151.57,171.98) R1X.1
  BOTTOM w0.47: v9(152.21,171.96) 152.06,171.96 arc(152.04,171.97) 152.02,171.98 arc(152.01,171.98) 152,171.98 151.92,171.99 arc(151.8,172.03) 151.71,172.11
  BOTTOM w0.762: T1X.5 149.99,173.06 arc(150.51,172.71) 151.13,172.67 arc(151.41,172.77) 151.59,172.53 arc(151.62,172.31) 151.71,172.11
DAC_N2: length 3.9
  BOTTOM w0.127: R1Y.1 151.76,167.21
  BOTTOM w0.47: 151.76,167.21 v9(152.21,167.15)
  BOTTOM w0.762: T1Y.5 149.53,166.29 arc(150.24,166.82) 151.06,167.14 151.76,167.21
DAC_N3: length 4.6
  TOP w0.254: R1Z.2 150.75,161.85
  TOP w0.508: U1AA.U1 arc(151.81,163.1) 151.51,162.84
  TOP w0.762: T1Z.5 150.26,161.77 arc(150.49,161.89) 150.75,161.85 arc(151.02,161.77) 151.31,161.83 arc(151.49,162.02) 151.48,162.28 arc(151.43,162.56) 151.51,162.84
DAC_P0: length 4.6
  TOP w0.279: R1W.1 151.06,176.61
  TOP w0.635: U1AA.B1 152.05,175.15 151.94,175.16 151.73,175.25 151.53,175.4 arc(151.5,175.57) 151.53,175.74 151.53,176.14
  TOP w0.762: T1W.4 arc(149.93,176.87) 150.26,176.56 arc(150.3,176.56) 150.33,176.56 151.06,176.61 arc(151.4,176.48) 151.53,176.14
DAC_P1: length 4
  BOTTOM w0.127: 151.31,171.14 151.51,171.34 arc(151.51,171.34) R1X.2
  BOTTOM w0.47: v9(152.21,171.15) 152.11,171.15 151.85,171.11 arc(151.58,171.1) 151.31,171.14
  BOTTOM w0.762: 151.31,171.14 150.68,171.29 arc(149.95,171.61) 149.26,172.02 T1X.4
DAC_P2: length 3.9
  BOTTOM w0.127: R1Y.2 151.51,166.35 arc(151.54,166.19) 151.63,166.06
  BOTTOM w0.279: 151.28,165.29 151.04,165.42
  BOTTOM w0.47: v9(152.21,166.34) 152.06,166.34 arc(152.04,166.33) 152.02,166.32 arc(152.01,166.32) 152,166.32 151.92,166.31 arc(151.8,166.27) 151.71,166.19 151.63,166.06
  BOTTOM w0.762: T1Y.4 150.26,165.25 arc(150.4,165.37) 150.58,165.42 151.04,165.42 arc(151.33,165.36) 151.49,165.6 arc(151.53,165.84) 151.63,166.06
DAC_P3: length 4.7
  TOP w0.254: R1Z.1 150.81,163.66
  TOP w0.635: U1AA.T1 151.86,163.91 151.28,163.84 arc(151.03,163.78) 150.81,163.66
  TOP w0.762: 150.81,163.66 149.56,162.81 T1Z.4
DAVDD1:
  vias: v1(155.41,172.75) v1(155.41,171.95) v1(155.41,166.35) v1(155.41,165.55) v1(156.21,173.55) v1(156.21,164.75) v1(159.41,173.55) v1(159.41,164.75) v4(179.7,177.62) v4(180.08,177.12) v4(180.21,176.48) v4(180.34,177.62)
DCLKVDD1: length 0.5
  TOP w0.241: E4X.2 184.26,176.62 v4(184.27,176.61)
  vias: v1(155.41,168.75) v1(156.21,169.55) v1(156.21,168.75) v1(157.01,169.55) v1(157.01,168.75) v4(183.51,176.61) v4(183.51,175.72) v4(184.27,175.72)
EXT_CLK: length 23.5
  TOP w0.279: T1D.2 120.75,169.16 EXT_CLK.1
EXT_REF: length 2.7
  TOP w0.241: EXT_HMCREF.1 156.08,118.69 v3(156.13,118.64)
  TOP w0.254: v3(156.13,118.64) 156.07,118.58 R23.1
  BOTTOM w0.241: C13B.1 v3(156.13,118.64)
EXT_SYNC: length 1.5
  TOP w0.241: R2E.2 EXT_SYNC.1
EXT_SYS_N: length 2
  TOP w0.241: C4C.2 139.28,125.97 arc(139.11,126.04) 139.04,126.21 EXT_SYS_N.1
EXT_SYS_P: length 2
  TOP w0.241: EXT_SYS_P.1 145.52,126.21 arc(145.45,126.04) 145.28,125.97 C2C.2
FPGA_AD7175_CS: length 37.8
  TOP w0.241: U2FF.14 170.72,141.47 v6(170.94,141.68)
  L3_SIGNAL w0.203: v3(184.91,129.62) 184.91,130.63 185.04,130.76 185.04,133.55 185.42,133.94 185.42,134.82 184.29,135.95 183.75,135.95 181.48,133.68 178.94,133.68 175.77,130.51 170.94,130.51 169.92,131.52 169.92,134.44 171.7,136.22 171.7,139.14 170.3,140.54 170.3,141.05 v6(170.94,141.68)
  BOTTOM w0.241: P1K.G24 v3(184.91,129.62)
FPGA_AGC0_0: length 28.6
  TOP w0.241: U4FF.14 164.2,124.96 165.22,125.98 165.22,126.57 v3(165.86,127.2)
  L10_SIGNAL w0.178: v2(188.05,134.08) 187.7,134.08 185.68,132.06 185.05,132.06 184.72,131.73 174.18,131.73 170.8,128.35 167,128.35 v3(165.86,127.2)
FPGA_AGC0_1: length 27.9
  TOP w0.241: U4FF.13 165.22,124.46 v1(165.48,124.71)
  L10_SIGNAL w0.178: v1(165.48,124.71) 166.67,124.71 167.64,125.68 169.8,125.68 173.86,129.74 182.42,129.74 183.79,131.12 185.16,131.12 185.75,131.7 186.36,131.7 187.45,132.79 188.04,132.79 v2(188.05,132.81)
FPGA_AGC1_0: length 33.1
  TOP w0.241: U4FF.12 v3(164.33,123.96)
  L10_SIGNAL w0.178: v2(189.32,131.54) 188.95,131.9 187.44,131.9 186.8,131.27 186.13,131.27 185.42,130.56 185.42,127.11 183.92,125.6 175.92,125.6 171.91,121.59 168.37,121.59 168.13,121.83 166.46,121.83 v3(164.33,123.96)
FPGA_AGC1_1: length 32.9
  TOP w0.241: v3(164.4,123.06) 164,123.46 U4FF.11
  L10_SIGNAL w0.178: v3(164.4,123.06) 165.96,121.5 167.99,121.5 168.33,121.16 172.82,121.16 176.48,124.82 183.82,124.82 185.93,126.93 185.93,130.3 186.51,130.89 188.7,130.89 v2(189.32,130.27)
FPGA_AGC2_0: length 19.9
  TOP w0.241: v3(171.45,129.87) 171.24,129.66 171.24,125.68 170.93,125.37 170.78,125.37 170.36,124.96 U5FF.14
  L10_SIGNAL w0.178: v3(171.45,129.87) 173.86,132.28 183.72,132.28 v2(184.24,132.81)
FPGA_AGC2_1: length 20.7
  TOP w0.241: v3(170.79,124.66) 170.58,124.46 U5FF.13
  L10_SIGNAL w0.178: v3(170.79,124.66) 174.28,128.16 183.15,128.16 183.56,127.75 v2(183.56,127.08)
  BOTTOM w0.241: v2(183.56,127.08) 183.56,130.85 P1K.G22
FPGA_AGC3_0: length 14.6
  TOP w0.241: U5FF.12 170.69,123.96 170.74,124 v3(170.8,124)
  L10_SIGNAL w0.178: v2(182.97,127.73) 182.33,127.08 174.42,127.08 171.35,124 v3(170.8,124)
FPGA_AGC3_1: length 14.3
  TOP w0.241: U5FF.11 170.7,123.46 170.79,123.37 v3(170.8,123.37)
  L10_SIGNAL w0.178: v5(182.97,126.46) 182.5,125.99 174.39,125.99 171.78,123.37 v3(170.8,123.37)
FPGA_GPIO0: length 51.1
  TOP w0.241: v3(151.13,129.24) 151.37,129 151.37,115.94 152.02,115.3 U6FF.10
  L10_SIGNAL w0.178: v3(151.13,129.24) 153.92,132.03 161.54,132.03 164.24,134.73 164.24,134.96 166.14,136.86 179.14,136.86 v2(179.65,136.35)
  BOTTOM w0.241: P1K.H19 182.97,135.39 182.4,135.97 180.03,135.97 v2(179.65,136.35)
FPGA_GPIO1: length 49.7
  TOP w0.241: U6FF.9 152.17,115.7 151.76,116.11 151.76,127.81 152.02,128.07 v3(152.02,128.98)
  L10_SIGNAL w0.178: v2(178.99,136.35) 169.62,136.35 167.38,134.11 165.1,134.11 162.63,131.65 154.68,131.65 v3(152.02,128.98)
  BOTTOM w0.241: v2(178.99,136.35) 179.84,135.5 179.84,134.94 180.09,134.7 182.37,134.7 182.97,134.09 P1K.H20
FPGA_GPIO2: length 44.2
  TOP w0.241: v3(152.52,117.93) 152.26,117.67 152.26,116.58 152.27,116.56 152.27,116.34 152.51,116.1 U6FF.8
  L10_SIGNAL w0.178: v2(178.94,123.9) 177.52,123.9 174.34,120.73 168.3,120.73 167.85,121.17 162.72,121.17 161.29,119.74 161.29,118.44 159.67,116.83 157.16,116.83 156.47,116.13 154.84,116.13 153.03,117.93 v3(152.52,117.93)
  BOTTOM w0.241: P1K.H22 182.97,131.49 182.37,130.89 182.37,130 181.99,129.62 181.35,129.62 181.1,129.36 181.1,128.6 180.85,128.35 180.08,128.35 178.94,127.2 v2(178.94,123.9)
FPGA_GPIO3: length 42.4
  TOP w0.241: v3(152.91,117.3) 152.65,117.04 152.65,116.74 152.89,116.5 U6FF.7
  L10_SIGNAL w0.178: v3(152.91,117.3) 154.46,115.75 156.55,115.75 157.3,116.49 160.41,116.49 161.8,117.88 161.8,119.48 163.15,120.84 167.72,120.84 168.21,120.35 174.65,120.35 177.47,123.17 179.22,123.17 v2(179.58,123.52)
  BOTTOM w0.241: v2(179.58,123.52) 179.58,126.82 179.8,127.04 181.85,127.04 182.37,127.56 182.37,129.11 182.38,129.12 182.38,129.24 182.97,129.83 P1K.H23
FPGA_GPIO4: length 60.6
  TOP w0.241: U7FF.10 159.68,115.3 158.86,116.12 158.86,117.18 v3(158.62,117.43)
  L10_SIGNAL w0.178: v2(188.05,137.89) 187.58,137.41 185.08,137.41 183,135.33 170.43,135.33 168.27,133.17 165.35,133.17 162.85,130.67 159.24,130.67 159.01,130.44 158.74,130.44 158.58,130.61 154.84,130.61 151.25,127.03 151.25,120.22 154.46,117.02 156.88,117.02 157.02,117.16 157.28,117.16 157.55,117.43 v3(158.62,117.43)
FPGA_GPIO5: length 58.9
  TOP w0.241: v3(159.26,117.68) 159.26,116.28 159.84,115.7 U7FF.9
  L10_SIGNAL w0.178: v3(159.26,117.68) 158.96,117.68 158.79,117.85 157.5,117.85 157.14,117.49 156.89,117.49 156.88,117.47 154.64,117.47 151.69,120.42 151.69,126.7 155.27,130.28 158.44,130.28 158.61,130.11 159.14,130.11 159.31,130.28 159.55,130.28 163.6,130.28 165.99,132.67 168.55,132.67 170.71,134.82 184.27,134.82 186.07,136.62 v2(188.05,136.62)
FPGA_GPIO6: length 59.3
  TOP w0.241: v3(160.02,117.81) 159.75,117.54 159.75,116.5 160.15,116.1 U7FF.8
  L10_SIGNAL w0.178: v2(189.32,136.62) 188.55,135.84 186.56,135.84 185.04,134.32 171.47,134.32 168.17,131.01 165.05,131.01 163.86,129.82 159.32,129.82 159.28,129.78 158.47,129.78 158.43,129.82 155.62,129.82 152.14,126.34 152.14,120.6 154.89,117.86 157.02,117.86 157.78,118.62 159.21,118.62 v3(160.02,117.81)
FPGA_GPIO7: length 57.4
  TOP w0.241: U7FF.7 160.31,116.5 160.14,116.67 160.14,117.17 160.53,117.55 v3(160.53,118.57)
  L10_SIGNAL w0.178: v2(189.32,135.35) 188.68,134.7 186.31,134.7 185.16,133.55 172.46,133.55 169.42,130.51 165.63,130.51 164.62,129.49 159.46,129.49 159.42,129.45 158.33,129.45 158.29,129.49 156.11,129.49 153.19,126.57 153.19,125.61 153.69,125.1 153.69,119.69 155.19,118.19 156.72,118.19 157.48,118.95 160.14,118.95 v3(160.53,118.57)
FPGA_GPIO8: length 30.9
  TOP w0.241: U8FF.10 168.39,115.3 168.33,115.25 168.26,115.25 168.2,115.19 168.15,115.19 v1(168.15,115.19)
  L3_SIGNAL w0.178: v1(168.15,115.19) 168.7,115.19 169.23,115.71 169.23,117.23 169.41,117.41 169.61,117.41 169.84,117.64 169.84,119.53 170.11,119.8 170.14,119.8 173.14,122.8 173.56,122.8 173.75,122.98 173.75,123.41 177.2,126.86 177.65,126.86 177.84,127.05 177.84,127.5 178.09,127.75 178.54,127.75 178.73,127.94 178.73,128.39 181.65,131.31 182.07,131.31 182.26,131.49 182.26,131.92 183.26,132.92 183.26,133.05 v3(184.91,134.7)
  BOTTOM w0.241: P1K.G18 184.26,136.62 184.91,135.97 v3(184.91,134.7)
FPGA_GPIO9: length 27.5
  TOP w0.241: U8FF.9 v6(168.15,115.7)
  L3_SIGNAL w0.178: v3(184.24,135.35) 182.5,133.6 182.5,133.05 181.37,131.92 181.37,131.62 181.18,131.43 180.88,131.43 179.74,130.29 179.74,130.07 179.56,129.88 179.38,129.88 169.29,119.8 169.29,118.45 168.95,118.11 168.95,116.25 168.4,115.7 v6(168.15,115.7)
FPGA_GPIO10: length 26.1
  TOP w0.241: v6(168.15,116.33) 168.38,116.1 U8FF.8
  L3_SIGNAL w0.178: v3(170.05,122.16) 169.03,121.15 169.03,119.98 169.01,119.95 169.01,118.57 168.14,117.69 168.14,116.34 v6(168.15,116.33)
  L10_SIGNAL w0.178: v3(170.05,122.16) 170.05,124.61 174.04,128.6 183.37,128.6 v2(184.24,127.73)
FPGA_HMC_GPIO1: length 76.8
  TOP w0.127: 144.56,103.17 144.69,103.04 145.28,103.04 145.34,102.98 U10FF.10
  TOP w0.241: v5(153.21,134.14) 152.73,134.14 148.59,130 148.59,126.19 147.47,125.07 146.1,125.07 144.55,123.52 142.11,123.52 139.44,120.85 139.44,109.93 140.84,108.54 140.84,105.11 142.78,103.17 144.56,103.17
  L10_SIGNAL w0.178: v5(153.21,134.14) 154.94,132.41 159.64,132.41 163.07,135.84 164.11,135.84 165.5,137.24 182.33,137.24 v2(182.97,137.89)
FPGA_IRQB0: length 16.2
  TOP w0.203: v6(172.37,142.37) 171.09,141.09 170.86,141.09 170.84,141.07 170.81,141.07 170.8,141.05 170.63,141.05 170.62,141.05 170.46,141.05 170.38,140.97 U2FF.13
  L3_SIGNAL w0.178: v6(172.37,142.37) 172.73,142.37 arc(172.81,142.39) 172.89,142.44 174.61,144.16 arc(174.68,144.21) 174.77,144.22 179.46,144.22 arc(179.54,144.21) 179.62,144.16 179.94,143.83 arc(180.01,143.78) 180.1,143.77 181.49,143.77 arc(181.58,143.78) 181.65,143.83 182.3,144.49 arc(182.38,144.54) 182.46,144.55 183.83,144.55 arc(183.92,144.54) 183.99,144.49 v3(184.24,144.24)
FPGA_IRQB1: length 15.7
  TOP w0.241: v6(170.81,140.65) 170.74,140.65 170.56,140.47 U2FF.12
  L3_SIGNAL w0.178: v6(170.81,140.65) 170.81,140.72 171.89,141.79 arc(171.96,141.84) 172.05,141.86 172.93,141.86 arc(173.02,141.88) 173.09,141.93 174.48,143.32 arc(174.55,143.37) 174.64,143.38 183.73,143.38 arc(183.82,143.37) 183.89,143.32 v3(184.24,142.97)
FPGA_REFCLK_IN_N: length 104
  L10_SIGNAL w0.133: v2(143.44,105.04) 143.44,105.46 143.69,105.71 143.69,106.04 143.56,106.17 143.04,106.17 142.83,105.96 arc(142.79,105.91) 142.78,105.84 142.78,102.58 arc(142.79,102.51) 142.83,102.46 144.75,100.54 162.46,100.54 arc(162.52,100.55) 162.58,100.59 170.01,108.02 arc(170.05,108.07) 170.1,108.11 arc(170.97,108.6) 171.96,108.76 178.1,108.76 arc(178.16,108.78) 178.22,108.81 181.9,112.5 arc(182.04,112.59) 182.21,112.63 182.6,112.63 arc(182.67,112.64) 182.72,112.68 184.68,114.63 arc(184.73,114.71) 184.75,114.81 184.75,114.81 184.75,117.76 arc(184.78,117.93) 184.88,118.07 188.91,122.1 arc(189.05,122.19) 189.22,122.23 189.69,122.23 arc(189.76,122.24) 189.81,122.28 190.81,123.28 arc(190.95,123.37) 191.11,123.4 192.04,123.4 192.4,123.76 192.4,144.6 192.26,144.73 189.01,144.73 188.59,145.15 188.59,147.25 188.88,147.53 189.5,147.53 189.91,147.94 189.91,153.34 189.61,153.63 188.19,153.63 188.05,153.5 v2(188.05,153.13)
  BOTTOM w0.241: C38B.2 v2(143.44,105.04)
FPGA_REFCLK_IN_P: length 106.1
  L10_SIGNAL w0.133: v2(188.05,154.4) 188.05,154.02 188.19,153.89 189.72,153.89 190.17,153.44 190.17,147.83 189.61,147.27 188.99,147.27 188.85,147.14 188.85,145.26 189.12,144.99 192.37,144.99 192.66,144.71 192.66,123.65 192.15,123.14 191.11,123.14 arc(191.05,123.13) 190.99,123.09 190,122.09 arc(189.86,122) 189.69,121.97 189.22,121.97 arc(189.15,121.95) 189.1,121.92 185.06,117.88 arc(185.02,117.83) 185.01,117.76 185.01,114.81 arc(184.97,114.61) 184.86,114.44 182.91,112.49 arc(182.77,112.4) 182.6,112.37 182.21,112.37 arc(182.14,112.35) 182.09,112.32 178.4,108.63 arc(178.26,108.54) 178.1,108.5 171.96,108.5 arc(170.94,108.3) 170.08,107.73 162.76,100.41 arc(162.62,100.31) 162.46,100.28 144.64,100.28 142.64,102.27 arc(142.55,102.41) 142.52,102.58 142.52,105.84 arc(142.55,106.01) 142.64,106.15 142.93,106.44 143.67,106.44 143.95,106.15 143.95,105.71 144.2,105.46 v2(144.2,105.04)
  BOTTOM w0.241: C37B.2 v2(144.2,105.04)
FPGA_RSTB: length 14.6
  TOP w0.241: v6(171.9,139.83) R1FF.2 171.38,139.53 170.94,139.97 U2FF.11
  L3_SIGNAL w0.178: v3(182.97,142.97) 182.96,142.95 175.36,142.95 arc(175.04,142.89) 174.77,142.71 v6(171.9,139.83)
FPGA_RXEN0: length 24.1
  TOP w0.241: U3FF.12 170.63,132.21 v6(171.07,131.78)
  L3_SIGNAL w0.178: v3(189.32,141.7) 188.72,141.09 188.72,140.41 188.08,139.78 187.96,139.78 187.32,139.14 184.91,139.14 184.27,138.51 179.07,138.51 172.34,131.78 v6(171.07,131.78)
FPGA_RXEN1: length 24
  TOP w0.241: v6(171.07,131.01) 170.37,131.71 U3FF.11
  L3_SIGNAL w0.178: v3(189.32,140.43) 188.72,139.82 188.72,139.1 188.12,138.51 185.67,138.51 184.4,137.24 178.56,137.24 172.34,131.01 v6(171.07,131.01)
FPGA_SERDIN_N0: length 12.1
  TOP w0.216: v5(191.86,150.59) 191.56,150.89 arc(191.49,150.94) 191.41,150.95 191.19,150.95 arc(190.63,151.19) 190.4,151.74 190.4,152.88 arc(190.3,153.38) 190.02,153.81 189.61,154.21 arc(188.88,155.31) 188.62,156.61 188.62,160.96 arc(188.59,161.09) C1J.1
FPGA_SERDIN_N1: length 11.7
  BOTTOM w0.216: C2J.1 178.17,151.54 arc(178.21,151.57) 178.26,151.57 179.36,151.57 arc(179.44,151.56) 179.51,151.51 179.75,151.27 arc(179.82,151.22) 179.91,151.21 188.53,151.21 arc(188.68,151.18) 188.81,151.09 189.32,150.59 P1K.C7
