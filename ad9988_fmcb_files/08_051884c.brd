# Allegro board 08_051884c.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
FPGA_SERDIN_N2: length 12.8
  BOTTOM w0.216: C3J.1 178.41,143.84 arc(178.49,143.86) 178.55,143.9 arc(178.61,143.94) 178.69,143.95 179.55,143.95 arc(179.8,143.9) 180.01,143.76 180.05,143.73 arc(180.2,143.62) 180.39,143.59 189.3,143.59 arc(189.41,143.58) 189.51,143.56 arc(190.09,143.33) 190.59,142.97 P1K.B13
FPGA_SERDIN_N3: length 9.4
  TOP w0.216: v5(190.59,137.89) 190.29,138.19 arc(190.22,138.24) 190.14,138.25 189.38,138.25 arc(188.03,138.52) 186.88,139.29 186.58,139.59 arc(185.83,140.09) 184.94,140.27 182.19,140.27 arc(182.08,140.22) C4J.1
FPGA_SERDIN_N4: length 0.4
  TOP w0.216: C5J.1 191.62,135.59 v5(191.86,135.35)
FPGA_SERDIN_N5: length 4.4
  TOP w0.216: v5(191.86,140.43) 191.56,140.73 arc(191.49,140.78) 191.41,140.79 191.19,140.79 arc(190.5,141.08) 190.22,141.76 190.22,142.44 arc(190.08,142.79) 189.74,142.93 189.24,142.93 C6J.1
FPGA_SERDIN_N6: length 0.4
  TOP w0.216: v5(191.86,145.51) 191.62,145.75 C7J.1
FPGA_SERDIN_N7: length 3.4
  TOP w0.216: v5(191.86,155.67) 191.56,155.97 arc(191.49,156.02) 191.41,156.03 191.19,156.03 arc(190.66,156.25) 190.44,156.78 190.44,157.94 arc(190.42,158.02) 190.38,158.09 190.37,158.09 C8J.1
FPGA_SERDIN_P0: length 11.2
  TOP w0.216: v5(191.86,151.86) 191.56,151.55 arc(191.49,151.5) 191.41,151.49 191.19,151.49 arc(191.01,151.56) 190.93,151.74 190.93,152.88 arc(190.79,153.59) 190.39,154.18 189.99,154.58 arc(189.37,155.51) 189.15,156.61 189.15,160.89 arc(189.19,161.06) C1I.1
FPGA_SERDIN_P1: length 11.7
  BOTTOM w0.216: P1K.C6 189.32,151.86 188.84,152.33 arc(188.68,152.44) 188.5,152.48 179.91,152.48 arc(179.82,152.46) 179.75,152.41 179.51,152.17 arc(179.44,152.12) 179.36,152.11 178.28,152.11 arc(178.17,152.13) C2I.1
FPGA_SERDIN_P2: length 12.8
  BOTTOM w0.216: P1K.B12 190.59,144.24 arc(190.03,144.63) 189.38,144.86 arc(189.27,144.88) 189.16,144.88 180.25,144.88 arc(180.15,144.86) 180.06,144.8 179.88,144.63 arc(179.73,144.52) 179.55,144.49 178.69,144.49 arc(178.61,144.5) 178.55,144.55 arc(178.49,144.59) 178.41,144.6 C3I.1
FPGA_SERDIN_P3: length 9.3
  TOP w0.216: v5(190.59,139.16) 190.29,138.85 arc(190.22,138.8) 190.14,138.79 189.38,138.79 arc(188.23,139.02) 187.25,139.67 186.96,139.97 arc(186.03,140.59) 184.94,140.8 182.09,140.8 arc(182.05,140.82) C4I.1
FPGA_SERDIN_P4: length 0.4
  TOP w0.216: v5(191.86,136.62) 191.6,136.36 C5I.1
FPGA_SERDIN_P5: length 4.3
  TOP w0.216: v5(191.86,141.7) 191.56,141.39 arc(191.49,141.34) 191.41,141.33 191.19,141.33 arc(190.88,141.46) 190.75,141.76 190.75,142.44 arc(190.45,143.16) 189.74,143.46 189.37,143.46 arc(189.28,143.5) C6I.1
FPGA_SERDIN_P6: length 0.4
  TOP w0.216: C7I.1 191.6,146.52 v5(191.86,146.78)
FPGA_SERDIN_P7: length 2.6
  TOP w0.216: C8I.1 191.13,158.15 191.04,158.06 arc(190.99,157.98) 190.97,157.89 190.97,156.78 arc(191.04,156.63) 191.19,156.57 191.41,156.57 arc(191.49,156.58) 191.56,156.63 v5(191.86,156.94)
FPGA_SERDOUT_N0: length 11.7
  BOTTOM w0.216: C1H.1 178.17,156.62 arc(178.21,156.65) 178.26,156.65 179.36,156.65 arc(179.44,156.64) 179.51,156.59 179.75,156.35 arc(179.82,156.3) 179.91,156.29 188.53,156.29 arc(188.68,156.26) 188.81,156.17 189.32,155.67 P1K.C3
FPGA_SERDOUT_N1: length 0.4
  TOP w0.216: C2H.1 191.6,125.45 v5(191.86,125.19)
FPGA_SERDOUT_N2: length 0.4
  TOP w0.216: v5(190.59,117.57) 190.35,117.81 C3H.1
FPGA_SERDOUT_N3: length 0.4
  TOP w0.216: v5(190.59,112.49) 190.35,112.73 C4H.1
FPGA_SERDOUT_N4: length 11.7
  TOP w0.216: v5(191.86,130.27) 191.56,130.57 arc(191.49,130.62) 191.41,130.63 190.9,130.63 arc(190.65,130.59) 190.43,130.48 arc(190.21,130.37) 189.96,130.33 180.69,130.33 arc(180.69,130.33) 180.69,130.33 arc(180.52,130.3) C5H.1
FPGA_SERDOUT_N5: length 14.4
  BOTTOM w0.216: P1K.A39 191.76,110.04 arc(191.16,110.45) 190.44,110.59 180.26,110.59 arc(180.15,110.62) 180.05,110.68 179.96,110.77 arc(179.76,110.9) 179.53,110.95 178.01,110.95 arc(177.88,110.92) C6H.1
FPGA_SERDOUT_N6: length 14.4
  BOTTOM w0.216: P1K.A35 191.76,115.12 arc(191.16,115.53) 190.44,115.67 180.36,115.67 arc(180.13,115.72) 179.93,115.85 arc(179.73,115.98) 179.5,116.03 178.01,116.03 arc(177.88,116) C7H.1
FPGA_SERDOUT_N7: length 11.7
  TOP w0.216: v5(191.86,120.11) 191.56,120.41 arc(191.49,120.46) 191.41,120.47 180.61,120.47 arc(180.51,120.45) 180.43,120.4 C8H.1
FPGA_SERDOUT_P0: length 11.7
  BOTTOM w0.216: P1K.C2 189.32,156.94 188.84,157.41 arc(188.68,157.52) 188.5,157.56 179.91,157.56 arc(179.82,157.54) 179.75,157.49 179.51,157.25 arc(179.44,157.2) 179.36,157.19 178.28,157.19 arc(178.17,157.21) C1G.1
FPGA_SERDOUT_P1: length 0.4
  TOP w0.216: v5(191.86,126.46) 191.62,126.21 C2G.1
FPGA_SERDOUT_P2: length 0.4
  TOP w0.216: v5(190.59,118.84) 190.32,118.57 C3G.1
FPGA_SERDOUT_P3: length 0.4
  TOP w0.216: C4G.1 190.32,113.49 v5(190.59,113.76)
FPGA_SERDOUT_P4: length 11.7
  TOP w0.216: v5(191.86,131.54) 191.56,131.23 arc(191.49,131.18) 191.41,131.17 190.9,131.17 arc(190.49,131.1) 190.11,130.91 arc(190.04,130.87) 189.96,130.86 180.62,130.86 arc(180.62,130.86) 180.62,130.86 arc(180.49,130.89) C5G.1
FPGA_SERDOUT_P5: length 14.4
  BOTTOM w0.216: C6G.1 177.77,111.6 arc(177.9,111.51) 178.06,111.48 179.55,111.48 arc(179.72,111.51) 179.86,111.61 179.91,111.66 arc(180.09,111.78) 180.3,111.82 181.1,111.82 arc(183.29,111.82) 185.47,111.83 190.5,111.85 arc(190.61,111.84) 190.71,111.82 190.95,111.77 arc(191.37,111.62) 191.73,111.34 P1K.A38
FPGA_SERDOUT_P6: length 14.4
  BOTTOM w0.216: P1K.A34 191.73,116.42 arc(191.19,116.79) 190.55,116.92 180.41,116.92 arc(180.11,116.86) 179.86,116.69 arc(179.72,116.59) 179.55,116.56 178.06,116.56 arc(177.9,116.59) 177.77,116.68 C7G.1
FPGA_SERDOUT_P7: length 11.7
  TOP w0.216: v5(191.86,121.38) 191.56,121.07 arc(191.49,121.02) 191.41,121.01 180.6,121.01 arc(180.49,121.03) 180.39,121.09 C8G.1
FPGA_TXEN0: length 22
  TOP w0.241: v6(170.74,133.55) 170.69,133.5 170.69,133.45 170.44,133.21 U3FF.14
  L3_SIGNAL w0.178: v3(188.05,141.7) 187.41,141.05 181.53,141.05 181.15,141.43 178.56,141.43 170.74,133.61 v6(170.74,133.55)
FPGA_TXEN1: length 21.3
  TOP w0.241: U3FF.13 v6(171.07,132.71)
  L3_SIGNAL w0.178: v6(171.07,132.71) 171.62,132.71 178.43,139.52 182.24,139.52 182.5,139.78 187.41,139.78 v3(188.05,140.43)
GA0: length 25.4
  L10_SIGNAL w0.178: v2(179.7,104.39) 186.25,104.39 191.26,109.4 191.26,115.27 190.88,115.65 189.97,115.65 v5(189.32,116.3)
  BOTTOM w0.241: U1K.2 178.25,102.94 v2(179.7,104.39)
GA1: length 20.9
  L10_SIGNAL w0.178: v2(178.82,104.39) 178.82,104.7 181.91,107.8 187.94,107.8 188.72,108.59 188.72,113.74 188.05,114.41 v5(188.05,115.03)
  BOTTOM w0.241: v2(178.82,104.39) 178.01,103.59 U1K.1
GPIO0: length 87.9
  TOP w0.203: U6FF.2 154.78,115.3
  TOP w0.241: 154.78,115.3 155.78,114.3 156.25,114.3 v6(156.84,113.72) 156.84,112.96 157.86,111.94 157.86,109.55 158.62,108.79 162.65,108.79 163.07,108.37 163.07,101.96 163.93,101.09 166.64,101.09 166.88,101.34 GPIO.3
  L3_SIGNAL w0.178: v6(156.84,113.72) 161.67,118.55 161.67,121.62 161.34,121.95 161.34,125.85 160.55,126.64 160.55,127.44 158.77,129.21 158.39,129.21 157.1,130.5 157.1,138.23 157.6,138.74 157.6,140.39 157.2,140.79 157.2,143.11 155.66,144.64 155.66,150.99 154.38,152.27 154.38,157.23 158.58,161.43 158.58,162.71 158.24,163.06 158.24,165.1 159.09,165.96 160.61,165.96 v1(161.01,166.35)
GPIO1: length 85.9
  TOP w0.203: 154.89,115.7 U6FF.3
  TOP w0.241: 154.89,115.7 155.46,115.7 155.84,115.32 v6(157.27,115.32) 157.48,115.11 157.48,112.88 158.24,112.12 158.24,109.93 158.93,109.25 165.71,109.25 166.88,108.08 GPIO.4
  L3_SIGNAL w0.178: v1(161.01,167.15) 160.63,167.53 160.63,168.18 160.45,168.35 156.82,168.35 156.61,168.15 156.61,167.79 156.36,167.54 156.03,167.54 155.83,167.34 155.83,164.55 155.57,164.29 154.43,164.29 154.18,164.03 154.18,163.78 154.18,163.78 153.92,163.53 152.91,163.53 152.65,163.27 152.65,162 152.91,161.75 152.91,157.3 152.65,157.05 152.65,143.66 154.99,141.33 154.99,131.02 158.24,127.76 158.24,126.25 159.12,125.36 159.52,125.36 160.35,124.53 160.35,122.84 159.83,122.32 159.83,120.92 156.88,117.97 156.88,115.71 v6(157.27,115.32)
GPIO2: length 85.5
  TOP w0.127: 167.53,105.19 167.53,108.51
  TOP w0.203: U6FF.4 154.88,116.1
  TOP w0.241: GPIO.5 168.15,103.83 168.17,103.86 168.17,104.55 167.53,105.19 ; 167.53,108.51 166.26,109.78 159.28,109.78 158.67,110.39 158.67,112.3 157.87,113.1 157.87,115.73 157.95,115.81 157.95,116.19 157.86,116.28 157.86,116.34 v6(157.54,116.66) 157.35,116.66 157.15,116.46 155.84,116.46 155.47,116.1 154.88,116.1
  L3_SIGNAL w0.178: v1(160.21,166.35) 159.78,166.78 158.47,166.78 158.19,166.5 158.19,166.14 157.99,165.94 157.63,165.94 157.43,165.74 157.43,163.03 157.69,162.76 157.95,162.76 158.19,162.52 158.19,161.57 154.05,157.43 154.05,151.97 155.26,150.76 155.26,144.49 156.84,142.9 156.84,138.97 156.73,138.86 156.73,130.4 158.25,128.88 158.6,128.88 160.22,127.26 160.22,126.02 160.16,125.96 160.16,125.66 161.01,124.8 161.01,121.77 161.21,121.57 161.21,120.91 161.07,120.76 161.07,120.75 158.11,117.79 158.11,117.24 v6(157.54,116.66)
GPIO3: length 83.4
  TOP w0.203: 154.9,116.5 U6FF.5
  TOP w0.241: 154.9,116.5 155.45,117.04 156.74,117.04 v6(157.3,117.6) 157.73,117.6 158.44,116.89 158.44,115.27 158.27,115.09 158.27,113.34 159.1,112.5 159.1,111.23 159.99,110.34 166.49,110.34 168.15,108.69 168.15,107.83 168.15,107.82 GPIO.6
  L3_SIGNAL w0.178: v1(160.21,167.15) 159.82,167.54 157.6,167.54 157.4,167.34 157.4,166.88 157.25,166.73 156.82,166.73 156.59,166.5 156.59,163.78 156.33,163.53 154.43,163.53 154.21,163.31 154.21,162.97 154.01,162.76 153.67,162.76 153.41,162.51 153.41,160.61 153.26,160.45 153.26,158.83 153.41,158.68 153.41,143.65 155.47,141.59 155.47,131.17 159.89,126.75 159.89,126.16 159.83,126.1 159.83,125.52 160.68,124.67 160.68,122.66 160.16,122.14 160.16,120.46 v6(157.3,117.6)
GPIO4: length 75.2
  TOP w0.127: 167.76,109.78 168.78,108.77 168.78,104.66
  TOP w0.241: U7FF.2 162.4,115.3 163.4,114.3 v6(164.46,114.3) 164.46,113.09 167.76,109.78 ; GPIO.7 169.42,104.02 168.78,104.66
  L3_SIGNAL w0.178: v1(160.21,165.55) 159.86,165.2 159.23,165.2 159,164.98 159,163.07 159.22,162.85 159.22,161.51 155.22,157.51 155.22,152.38 156.11,151.49 156.11,144.73 157.66,143.18 157.66,142.15 158.34,141.47 158.34,137.47 157.4,136.53 157.4,130.66 158.53,129.54 159.08,129.54 161.67,126.95 161.67,122.12 162.05,121.74 162.05,116.71 v6(164.46,114.3)
GPIO5: length 69.7
  TOP w0.241: GPIO.8 169.42,107.82 169.39,107.85 169.39,108.78 165.28,112.89 165.28,114.56 164.52,115.32 v6(164.46,115.32) 163.46,115.32 163.08,115.7 U7FF.3
  L3_SIGNAL w0.178: v1(160.21,164.75) 159.77,164.31 159.77,161.57 155.55,157.36 155.55,152.53 156.44,151.64 156.44,144.98 158.77,142.65 158.77,137.26 157.81,136.3 157.81,130.73 158.66,129.87 159.22,129.87 162.88,126.21 162.88,119.97 162.43,119.52 162.43,117.34 v6(164.46,115.32)
GPIO6: length 73.9
  TOP w0.127: 170.03,108.64 170.03,105.39
  TOP w0.241: 170.03,105.39 170.69,104.72 GPIO.9 ; 164.46,116.46 163.46,116.46 163.09,116.1 U7FF.4 ; 164.46,116.46 v6(164.47,116.46) ; 164.46,116.46 164.46,116.44 165.68,115.22 165.68,113.23 170.03,108.89 170.03,108.64
  L3_SIGNAL w0.178: v1(161.81,166.35) 161.82,166.35 162.18,165.99 164.34,165.99 164.59,165.74 164.59,162.08 163.85,161.34 163.85,159.18 165.05,157.99 165.05,154.64 164.6,154.2 164.6,153.25 164.46,153.11 164.46,146.51 165.61,145.37 165.61,141.81 165.36,141.57 165.36,133.86 164.54,133.04 164.54,127.23 163.56,126.25 163.56,124.88 163.62,124.82 163.62,118.39 163.88,118.14 163.88,117.05 v6(164.47,116.46)
GPIO7: length 70.9
  TOP w0.241: 164.49,117.6 166.19,115.9 166.19,113.46 170.69,108.97 170.69,106.94 GPIO.10 ; 164.49,117.6 v6(164.5,117.6) ; 164.49,117.6 163.46,117.6 162.35,116.5 U7FF.5
  L3_SIGNAL w0.178: v1(161.81,167.15) 162.2,166.75 165.1,166.75 165.48,166.37 165.48,160.47 165.26,160.25 165.26,159.44 165.48,159.22 165.48,151.62 164.97,151.11 164.97,146.79 165.94,145.82 165.94,141.67 165.69,141.43 165.69,133.73 164.87,132.9 164.87,126.86 163.89,125.89 163.89,125.08 163.95,125.02 163.95,118.7 164.5,118.15 v6(164.5,117.6)
GPIO8: length 79.2
  TOP w0.241: U8FF.2 170.91,115.3 v6(172.02,114.19) ; GPIO.11 171.96,104.27 v6(172.59,104.9)
  L3_SIGNAL w0.178: v1(161.81,167.95) 162.24,167.51 165.99,167.51 166.24,167.26 166.24,162.16 165.81,161.73 165.81,160.4 165.54,160.13 165.54,159.55 165.81,159.29 165.81,151.13 165.38,150.7 165.38,147.35 166.43,146.29 166.43,139.07 166.03,138.67 166.03,136.84 166.41,136.46 166.41,136.19 166.03,135.81 166.03,133.59 165.22,132.79 165.22,130.13 166.83,128.53 166.83,126.19 166.9,126.12 166.9,119.83 v3(166.83,119.76) ; v3(171.57,117.68) 171.57,116.99 172.02,116.55 v6(172.02,114.19) ; 173,112.47 173,110.33 172.59,109.92 v6(172.59,104.9)
  L3_SIGNAL w0.203: 173,112.47 173,113.21 v6(172.02,114.19)
  L10_SIGNAL w0.178: v3(171.57,117.68) 170.64,117.68 170.51,117.81 167.51,117.81 166.9,118.42 166.9,119.69 v3(166.83,119.76)
GPIO9: length 74.8
  TOP w0.241: v6(171.57,115.7) U8FF.3 ; GPIO.12 v3(171.96,107.82)
  L3_SIGNAL w0.178: 171.96,108.92 v3(171.96,107.82) ; v3(168.02,118.44) 168.02,119.71 167.64,120.09 167.64,128.35 165.73,130.25 165.73,132.83 166.36,133.45 166.36,135.67 166.76,136.08 166.76,150.26 166.09,150.93 166.09,159.42 166.07,159.42 165.82,159.67 165.82,160.02 166.07,160.26 166.09,160.26 166.09,161.61 166.6,162.12 166.6,167.79 165.99,168.4 162.15,168.4 v1(161.81,168.75) ; v3(171.07,119.14) 171.07,118.4 170.78,118.11 170.78,116.5 v6(171.57,115.7) 171.57,113.75
  L3_SIGNAL w0.203: 171.57,113.75 171.83,113.49 171.83,112.35 171.07,111.58 171.07,110.69 171.96,109.8 171.96,108.92
  L10_SIGNAL w0.178: v3(168.02,118.44) 170.43,118.44 171.07,119.08 v3(171.07,119.14)
GPIO10: length 82.5
  TOP w0.241: GPIO.13 v3(173.23,102.11) ; v3(173.73,115.39) 172.85,116.28 172.08,116.28 171.54,116.28 171.35,116.1 U8FF.4
  L3_SIGNAL w0.178: v3(163.32,118.06) 163.32,118.61 163.29,118.64 163.29,124.59 163.23,124.65 163.23,127.32 160.35,130.2 158.8,130.2 158.21,130.79 158.21,135.82 159.18,136.78 159.18,142.88 157.99,144.07 157.99,150.7 156.03,152.66 156.03,157.3 160.66,161.93 160.66,163.58 161.01,163.93 v1(161.01,163.95) ; v3(173.23,102.11) 173.23,106.25 173.86,106.88 173.86,112.73 173.73,112.86 v3(173.73,115.39)
  L10_SIGNAL w0.178: v3(163.32,118.06) 163.65,118.06 164.97,116.74 172.39,116.74 v3(173.73,115.39)
HMC_3P3V: length 17
  TOP w0.508: v5(146.17,123.14) 145.16,122.12 E1OO.2 ; v5(139.7,103.71) 139.4,103.41 HMC_STATUS.A
  L3_SIGNAL w0.508: v5(146.17,123.14) 146.17,119.78 146.74,119.21 v4(146.74,119.12)
  BOTTOM w0.203: U1B.17 142.14,116.63 141.86,116.92 141.86,117.04 v5(141.73,117.17) ; U1B.26 147.25,118.61 v4(146.74,119.12)
  BOTTOM w0.254: U1B.68 143.25,107.41 142.55,106.71 C26B.1 ; U1B.57 v5(148.75,108.75)
  BOTTOM w0.508: C21B.2 140.17,117.59 v5(140.46,117.3) ; v5(141.76,106.25) 141.86,106.25 141.96,106.15 C26B.1 ; v5(146.17,123.14) 145.16,122.12 C6OO.1
HMC_3P3V_PLL: length 18.9
  TOP w0.203: v5(172.46,111.96) 172.97,111.46 173.23,111.46
  TOP w0.508: E2OO.2 173.49,109.79 v5(171.83,111.46) ; v5(171.83,111.46) 172.34,111.96 v5(172.46,111.96) ; v5(171.83,111.46) C17OO.1
  BOTTOM w0.203: U1B.41 151.4,113.63 151,113.23 v5(151,112.47) ; U1B.21 144.75,118.65 v4(145.22,119.12) ; C24B.2 154.71,115.13 U1B.38 ; 152.1,108.35 U1B.51
  BOTTOM w0.381: v2(154.43,111.71) 154.85,112.13 C25B.2 ; v3(157.5,116) 155.54,116 155.45,115.9
  BOTTOM w0.508: 152.1,108.35 152.33,108.12 v4(152.33,106.15) ; C24B.2 155.13,115.59 155.45,115.9
HMC_3P3V_VCO: length 7.4
  TOP w0.508: v5(167.41,117.33) 167.94,117.33 E3OO.2
  BOTTOM w0.203: v2(139.75,114.03) 139.75,114.03 140.65,113.13 U1B.10
  BOTTOM w0.508: v5(167.41,117.33) 168.4,117.33 C8OO.1 ; v5(152.57,124.36) E2B.1 v5(153.04,124.67)
  vias: v2(140.08,113.74)
HMC_CLK_N: length 4.7
  BOTTOM w0.102: C1D.1 141.24,118.09 141.24,116.1 141.34,116 141.49,116 141.62,116.13 U1B.16
  BOTTOM w0.241: 141.6,119.27 C1D.1
  BOTTOM w0.279: L1D.1 141.6,119.27
HMC_CLK_P: length 5.1
  BOTTOM w0.102: C1D.2 141.01,118.02 141.01,116.01 141.25,115.77 141.49,115.77 141.62,115.63 U1B.15
  BOTTOM w0.241: 140.59,119.27 C1D.2
  BOTTOM w0.279: L2D.1 140.59,119.27
HMC_CPOUT1: length 18
  BOTTOM w0.241: Y2B.1 159.46,126.65 159.13,126.32 155.45,126.32 154.68,125.55 152.52,125.55 152.02,125.05 152.02,122.05 152.45,121.61 152.45,119.7 151.87,119.12 C44B.1 C43B.1 150.25,118.69 U1B.32
HMC_GPIO1: length 20.1
  TOP w0.241: U10FF.2 147.47,102.98 147.95,102.98 148.03,102.9 v6(148.14,102.9)
  L3_SIGNAL w0.178: v3(149.48,118.7) 149.48,115.65 148.59,114.76 148.59,110.69 149.35,109.93 149.35,105.18 149.35,105.18 149.35,104.86 149.86,104.34 149.86,103.65 148.99,102.78 148.25,102.78 v6(148.14,102.9)
  BOTTOM w0.241: v3(149.48,118.7) 149.75,118.42 U1B.31
HMC_SCLK: length 17.6
  TOP w0.241: v6(148.08,104.37) 147.89,104.18 U10FF.5
  L3_SIGNAL w0.178: v6(148.08,104.37) 147.55,104.9 147.55,105.44 143.63,109.35 v3(143.63,118.44)
  BOTTOM w0.241: U1B.19 143.75,118.33 v3(143.63,118.44)
HMC_SDATA: length 19.8
  TOP w0.241: v6(149.35,104.22) 149.05,104.22 148.69,103.86 148.13,103.86 148.05,103.78 147.47,103.78 U10FF.4
  L3_SIGNAL w0.178: v3(144.25,118.44) 144.23,118.43 144.23,109.46 146.05,107.65 146.81,107.65 148.33,106.12 148.33,105.23 v6(149.35,104.22)
  BOTTOM w0.241: U1B.20 v3(144.25,118.44)
HMC_SLEN: length 20.9
  TOP w0.241: U10FF.3 148.64,103.38 v6(148.82,103.2)
  L3_SIGNAL w0.178: v6(148.82,103.2) 148.56,103.46 147.32,103.46 146.05,104.73 146.05,106.25 143,109.3 v3(143,118.44)
  BOTTOM w0.241: v3(143,118.44) 143,118.31 143.25,118.06 U1B.18
HMC_SYNC: length 65.6
  TOP w0.241: v3(140.46,110.95) 140.71,111.2 R1E.1
  L10_SIGNAL w0.178: v3(140.46,110.95) 140.46,116.03 141.09,116.66 141.09,119.08 146.11,124.09 146.11,132.72 149.8,136.41 159.83,136.41 162.68,139.27 172.49,139.27 174.55,141.33 182.6,141.33 v2(182.97,141.7)
HMC_SYSREF_N: length 12.8
  TOP w0.102: v6(141.98,124.41) 141.73,124.66 140.66,124.66 C3C.1
  L3_SIGNAL w0.133: v6(141.98,124.41) 142.23,124.16 142.23,115.13 142.1,115 141.65,115 141.48,115.17 v3(141.47,115.17)
  BOTTOM w0.102: v3(141.47,115.17) 141.64,115.01 141.93,115.01 142.06,115.13 U1B.14
HMC_SYSREF_P: length 13
  TOP w0.102: C1C.1 143.89,124.66 143,124.66 v6(142.75,124.41)
  L3_SIGNAL w0.133: v6(142.75,124.41) 142.49,124.16 142.49,115.02 142.21,114.74 141.61,114.74 v3(141.48,114.61)
  BOTTOM w0.102: v3(141.48,114.61) 141.65,114.78 141.85,114.78 141.99,114.63 U1B.13
IRQB0: length 34.1
  TOP w0.241: U2FF.4 165.05,140.97 163.07,142.95 161.9,142.95 v5(161.72,143.13) ; 162.91,158.22 162.65,157.96 v3(162.35,157.96)
  TOP w0.279: 162.91,158.22 162.91,158.23 R4.2
  L3_SIGNAL w0.178: v3(162.35,157.96) 162.43,157.96 162.86,157.53 162.86,153.11 160.91,151.16 160.91,143.94 v5(161.72,143.13)
  BOTTOM w0.127: v1(161.01,165.55) 160.64,165.18 160.64,161.91
  BOTTOM w0.241: 160.64,161.91 160.23,161.5 160.23,160.12 160.84,159.51 160.84,158.52 161.13,158.22 161.89,158.22 162.15,157.96 v3(162.35,157.96) 162.13,158.19 TP1.1
IRQB1: length 32.9
  TOP w0.241: U2FF.5 166.54,140.47 166.41,140.6 164.51,140.6 163.45,141.66 161.69,141.66 161.54,141.81 v5(161.29,141.81) ; 162.91,159.89 161.97,159.89 v3(161.67,159.59)
  TOP w0.279: 162.91,159.89 R5.2
  L3_SIGNAL w0.178: v3(161.67,159.59) 161.92,159.34 161.92,157.79 162.25,157.46 162.25,157.02 162.08,156.85 162.08,156.36 162.46,155.98 162.46,153.21 160.47,151.23 160.47,142.88 161.29,142.06 v5(161.29,141.81)
  BOTTOM w0.127: v1(161.01,164.75) 161.42,164.34 161.42,161.8
  BOTTOM w0.241: 161.42,161.8 161.67,161.54 v3(161.67,159.59)
Net_3:
  vias: v1(154.61,167.95)
Net_4:
  vias: v1(154.61,170.35)
Net_5: length 4.6
  L10_SIGNAL w0.178: v2(168.02,169.04) 166.5,167.51 164.64,167.51 v1(164.21,167.95)
Net_6: length 3.7
  L10_SIGNAL w0.178: v2(166.62,169.04) 165.99,168.4 163.86,168.4 v1(163.41,167.95)
PG_C2M: length 71.9
  TOP w0.508: TP13K.1 186.71,217.24 R14.1
  L10_SIGNAL w0.508: v2(188.05,158.21) 188.05,158.41 188.59,158.95 189.1,158.95 191.13,160.99 191.13,178.64 189.1,180.67 189.1,185.37 188.47,186.01 188.47,189.6 186.6,191.47 184.78,191.47 182.24,194.01 182.24,195.4 183.51,196.67 183.51,204.04 189.61,210.14 189.61,216.14 TP13K.1
PLLCLKVDD1: length 0.9
  BOTTOM w0.241: R22.2 v3(171.45,181.94)
  vias: v1(155.41,169.55)
RESETB: length 113.5
  TOP w0.241: v3(163.77,139.98) 164.97,139.96 R8FF.2 ; RESET.1B RESET.1A 133.65,105.36 v3(132.59,105.36)
  L3_SIGNAL w0.178: v1(161.01,174.35) 161.41,173.94 161.97,173.94 161.97,173.94 166.62,173.94 170.24,170.32 170.24,146.27 171.4,145.11 v3(172.34,145.11)
  L10_SIGNAL w0.178: v3(172.34,145.11) 172.34,144.55 167.77,139.98 v3(163.77,139.98) 162.42,139.98 159.18,136.74 156.8,136.74 156.26,137.29 150.01,137.29 145.57,132.84 145.57,124.97 143.51,122.91 139.06,122.91 132.59,116.44 v3(132.59,105.36)
RXEN0: length 48.1
  TOP w0.241: U3FF.5 v3(166.42,132.21)
  L3_SIGNAL w0.178: v3(166.42,132.21) 166.42,133.05 166.69,133.31 166.69,135.54 167.1,135.96 167.1,141.78 169.29,143.97 169.29,169.24 166.14,172.39 162.17,172.39 v1(161.81,172.75)
RXEN1: length 51.4
  TOP w0.241: U3FF.6 166.56,131.71 v3(166.37,131.52)
  L3_SIGNAL w0.178: v3(166.37,131.52) 167.05,132.21 167.05,132.95 171.09,136.98 171.09,139.04 169.8,140.34 169.8,157.56 169.8,157.56 169.8,169.88 166.5,173.18 162.18,173.18 v1(161.81,173.55)
SCL: length 40.8
  L10_SIGNAL w0.178: v2(174.12,105.16) 174.83,105.87 178.33,105.87 181.84,109.37 185.62,109.37 187.2,110.95 187.2,117.09 188.7,118.59 188.7,120.75 189.32,121.38 v2(189.32,121.38)
  BOTTOM w0.241: TP7K.1 163.12,103.4 166.29,103.4 167.41,102.29 169.62,102.29 169.62,102.29 U1K.6 171.71,102.29 174.12,104.7 v2(174.12,105.16)
SDA: length 39.6
  L10_SIGNAL w0.178: v2(174.88,105.16) 178.53,105.16 181.61,108.23 187.04,108.23 187.58,108.77 187.58,116.46 189.74,118.62 189.74,119.69 v2(189.32,120.11)
  BOTTOM w0.241: TP5K.1 166.32,102.62 167.29,101.64 U1K.5 171.87,101.64 174.88,104.65 v2(174.88,105.16)
SERDIN_N0: length 20.7
  TOP w0.127: 166.45,167.57 166.39,167.57 arc(166.38,167.57) 166.37,167.57 165.97,167.57 arc(165.91,167.56) 165.85,167.56 arc(165.8,167.56) 165.75,167.56 arc(165.71,167.56) 165.67,167.57 165.62,167.57 arc(165.41,167.61) 165.23,167.73 U1AA.L17
  TOP w0.216: 166.45,167.57 169.28,167.57 arc(173.18,165.96) 174.8,162.05 174.8,157.86 arc(175.16,157) 176.02,156.64 176.96,156.64 arc(177.05,156.6) v1(177.09,156.51)
  BOTTOM w0.216: C1H.2 v1(177.09,156.51)
SERDIN_N1: length 58.5
  TOP w0.127: U1AA.N17 165.23,166.13 arc(165.41,166.01) 165.62,165.97 165.67,165.97 arc(165.71,165.96) 165.75,165.96 arc(165.8,165.96) 165.85,165.96 arc(165.91,165.96) 165.97,165.97 166.37,165.97 arc(166.38,165.97) 166.39,165.97 166.45,165.97
  TOP w0.216: 166.45,165.97 168.78,165.97 arc(171.67,164.78) 172.87,161.88 172.87,158.49 arc(173.05,157.21) 173.57,156.03 arc(173.8,155.7) 174.07,155.4 176.2,153.27 arc(176.96,152.14) 177.22,150.81 177.22,137.83 arc(177.32,136.75) 177.61,135.7 arc(177.9,134.65) 178,133.56 178,130.23 arc(178.54,128.93) 179.83,128.4 184.71,128.4 arc(185.35,128.27) 185.89,127.91 186.83,126.97 arc(188.37,125.94) 190.2,125.58 190.64,125.58 arc(190.8,125.54) C2H.2
SERDIN_N2: length 64.2
  TOP w0.127: U1AA.R17 165.23,164.53 arc(165.41,164.41) 165.62,164.37 165.67,164.37 arc(165.71,164.36) 165.75,164.36 arc(165.8,164.36) 165.85,164.36 arc(165.91,164.36) 165.97,164.37 166.37,164.37 arc(166.38,164.37) 166.39,164.37 166.45,164.37
  TOP w0.216: 166.45,164.37 167.59,164.37 arc(169.95,163.4) 170.93,161.04 170.93,158.69 arc(171.42,156.23) 172.81,154.15 174.03,152.93 arc(175.04,151.41) 175.4,149.62 175.4,137.79 arc(175.52,136.53) 175.8,135.3 arc(176.1,133.86) 176.2,132.39 176.2,122.17 arc(177.45,119.17) 180.45,117.92 189.08,117.92 arc(189.15,117.9) 189.22,117.86 arc(189.28,117.82) 189.35,117.81 C3H.2
SERDIN_N3: length 66.7
  TOP w0.127: U1AA.U17 165.23,162.93 arc(165.41,162.81) 165.62,162.77 165.67,162.77 arc(165.71,162.76) 165.75,162.76 arc(165.8,162.76) 165.85,162.76 arc(165.91,162.76) 165.97,162.77 166.37,162.77 arc(166.38,162.77) 166.39,162.77 166.45,162.77
  TOP w0.216: 166.45,162.77 166.46,162.77 arc(168.17,162.06) 168.88,160.35 168.88,157.57 arc(169.33,155.31) 170.62,153.39 172.11,151.9 arc(173.2,150.27) 173.58,148.35 173.58,148.13 173.6,148.11 173.6,143.33 173.58,143.31 173.58,135.9 arc(173.67,135.26) 173.91,134.67 arc(174.16,134.08) 174.24,133.45 174.24,120.98 arc(176.7,115.05) 182.63,112.6 188.15,112.6 arc(188.54,112.65) 188.9,112.79 arc(189.01,112.84) 189.13,112.85 189.37,112.85 arc(189.53,112.82) C4H.2
SERDIN_N4: length 47.4
  TOP w0.216: C5H.2 v1(179.43,130.2)
  BOTTOM w0.127: 164.7,166.88 arc(164.64,166.87) 164.59,166.87 164.45,166.84 arc(164.42,166.83) 164.38,166.81 arc(164.34,166.78) 164.3,166.78 163.27,166.78 arc(162.89,166.88) v1(162.61,167.15)
  BOTTOM w0.216: 164.7,166.88 166.7,166.88 arc(169.36,165.96) 170.89,163.6 arc(170.91,163.5) 170.92,163.39 170.92,142.56 arc(171.04,141.94) 171.39,141.42 177.08,135.73 arc(177.58,134.99) 177.75,134.11 177.75,131.61 arc(178.13,130.69) 179.04,130.31 179.15,130.31 arc(179.3,130.29) v1(179.43,130.2)
SERDIN_N5: length 58.2
  BOTTOM w0.127: v1(162.61,162.35) 162.65,162.31 arc(162.73,162.18) 162.76,162.03 162.76,160.76 162.76,160.59 162.76,160.17
  BOTTOM w0.216: 162.76,160.17 162.76,158.79 arc(162.77,158.78) 162.79,158.77 arc(162.84,158.48) 163.01,158.24 165.09,156.16 arc(166.19,154.51) 166.57,152.57 166.57,150.21 166.57,143.71 166.57,139.9 arc(166.88,138.38) 167.74,137.1 171.54,133.3 arc(172.02,132.58) 172.19,131.73 172.19,114.76 arc(173.3,112.07) 175.98,110.96 176.53,110.96 arc(176.61,110.95) 176.67,110.9 arc(176.73,110.86) 176.81,110.85 C6H.2
SERDIN_N6: length 56.9
  BOTTOM w0.127: v1(162.61,163.95) arc(162.89,163.68) 163.27,163.58 164.3,163.58 arc(164.34,163.58) 164.38,163.61 arc(164.42,163.63) 164.45,163.64 164.63,163.68 arc(164.64,163.68) 164.65,163.68
  BOTTOM w0.216: 164.65,163.68 166.18,163.68 arc(167.54,163.12) 168.1,161.76 ; 168.1,161.76 168.1,161.76 ; 168.1,161.76 168.1,161.76 ; 168.1,161.76 168.1,152.96 168.13,152.93 168.13,152.53 168.1,152.5 168.1,141.12 arc(168.4,139.58) 169.28,138.28 173.09,134.46 arc(173.87,133.29) 174.14,131.91 174.14,117.77 arc(174.65,116.55) 175.87,116.04 176.53,116.04 arc(176.61,116.03) 176.67,115.98 arc(176.73,115.94) 176.81,115.93 C7H.2
SERDIN_N7: length 55.4
  TOP w0.216: C8H.2 v1(179.43,120.35)
  BOTTOM w0.127: 164.7,165.28 arc(164.64,165.27) 164.59,165.27 164.45,165.24 arc(164.42,165.23) 164.38,165.21 arc(164.34,165.18) 164.3,165.18 163.27,165.18 arc(162.89,165.28) v1(162.61,165.55)
  BOTTOM w0.216: v1(179.43,120.35) 178.9,120.35 arc(178.83,120.36) 178.76,120.4 arc(178.7,120.45) 178.63,120.46 arc(177.36,120.99) 176.83,122.25 176.83,127.13 arc(176.72,127.97) 176.38,128.76 arc(176.05,129.48) 175.92,130.26 175.92,132.08 arc(175.56,133.89) 174.53,135.43 170.08,139.88 arc(169.68,140.48) 169.54,141.18 169.54,162.38 arc(168.7,164.43) 166.65,165.28 164.7,165.28
SERDIN_P0: length 20.7
  TOP w0.127: U1AA.L18 165.63,167.95 arc(165.52,168) 165.48,168.11 arc(165.55,168.27) 165.71,168.34 165.95,168.34 arc(166.08,168.31) 166.19,168.23 arc(166.28,168.17) 166.38,168.13 166.43,168.11 arc(166.44,168.11) 166.45,168.11
  TOP w0.216: v1(177.09,157.28) 177.09,157.18 176.02,157.18 arc(175.54,157.38) 175.34,157.86 175.34,162.05 arc(173.56,166.33) 169.28,168.11 166.45,168.11
  BOTTOM w0.216: C1G.2 v1(177.09,157.28)
SERDIN_P1: length 58.5
  TOP w0.127: U1AA.N18 165.63,166.35 arc(165.52,166.4) 165.48,166.51 arc(165.55,166.67) 165.71,166.74 165.95,166.74 arc(166.08,166.71) 166.19,166.63 arc(166.28,166.57) 166.38,166.53 166.43,166.51 arc(166.44,166.51) 166.45,166.51
  TOP w0.216: 166.45,166.51 168.78,166.51 arc(172.05,165.15) 173.41,161.88 173.41,158.49 arc(173.56,157.36) 174.02,156.31 arc(174.22,156.03) 174.45,155.78 176.58,153.64 arc(177.45,152.35) 177.75,150.81 177.75,137.84 arc(177.84,136.85) 178.11,135.89 arc(178.43,134.75) 178.54,133.56 178.54,130.23 arc(178.92,129.31) 179.83,128.93 184.71,128.93 arc(185.55,128.76) 186.27,128.28 187.2,127.35 arc(188.58,126.43) 190.2,126.11 190.7,126.11 arc(190.83,126.14) C2G.2
SERDIN_P2: length 64.2
  TOP w0.127: U1AA.R18 165.63,164.75 arc(165.52,164.8) 165.48,164.91 arc(165.55,165.07) 165.71,165.14 165.95,165.14 arc(166.08,165.11) 166.19,165.03 arc(166.28,164.97) 166.38,164.93 166.43,164.91 arc(166.44,164.91) 166.45,164.91
  TOP w0.216: 166.45,164.91 167.59,164.91 arc(170.33,163.77) 171.46,161.04 171.46,158.69 arc(171.91,156.43) 173.19,154.52 174.41,153.3 arc(175.54,151.61) 175.93,149.62 175.93,137.8 arc(176.05,136.61) 176.31,135.44 arc(176.63,133.93) 176.73,132.39 176.73,122.17 arc(177.82,119.54) 180.45,118.45 189.08,118.45 arc(189.15,118.47) 189.22,118.51 arc(189.28,118.55) 189.35,118.57 C3G.2
SERDIN_P3: length 66.7
  TOP w0.127: U1AA.U18 165.63,163.15 arc(165.52,163.2) 165.48,163.31 arc(165.55,163.47) 165.71,163.54 165.95,163.54 arc(166.08,163.51) 166.19,163.43 arc(166.28,163.37) 166.38,163.33 166.43,163.31 arc(166.44,163.31) 166.45,163.31
  TOP w0.216: 166.45,163.31 166.46,163.31 arc(168.55,162.44) 169.42,160.35 169.42,157.57 arc(169.83,155.52) 170.99,153.77 172.49,152.27 arc(173.69,150.47) 174.12,148.35 174.13,148.33 174.13,143.1 174.12,143.09 174.12,135.9 arc(174.18,135.4) 174.38,134.94 arc(174.41,134.88) 174.45,134.83 arc(174.69,134.32) 174.78,133.75 174.78,120.98 arc(177.08,115.43) 182.63,113.13 188.15,113.13 arc(188.4,113.16) 188.64,113.26 arc(188.88,113.35) 189.13,113.39 189.43,113.39 arc(189.56,113.41) C4G.2
SERDIN_P4: length 47.4
  TOP w0.216: C5G.2 v1(179.43,130.96)
  BOTTOM w0.127: v1(163.41,167.15) arc(163.32,167.15) 163.23,167.18 163.15,167.22 arc(163.05,167.4) 163.22,167.54 164.29,167.54 arc(164.33,167.53) 164.38,167.5 arc(164.44,167.45) 164.52,167.43 164.6,167.42 arc(164.63,167.41) 164.66,167.41
  BOTTOM w0.216: 164.66,167.41 166.7,167.41 arc(169.69,166.38) 171.41,163.73 arc(171.44,163.56) 171.45,163.39 171.45,142.56 arc(171.53,142.15) 171.77,141.8 177.46,136.11 arc(178.07,135.19) 178.28,134.11 178.28,131.61 arc(178.51,131.07) 179.04,130.85 179.15,130.85 arc(179.3,130.88) v1(179.43,130.96)
SERDIN_P5: length 58.2
  BOTTOM w0.127: v1(163.41,162.35) 163.29,162.23 arc(163.23,162.14) 163.21,162.04 arc(163.21,162.04) 163.21,162.03 163.21,161.9 arc(163.23,161.83) 163.28,161.79 163.96,161.41 arc(164.11,161.17) 163.97,160.93 163.69,160.75
  BOTTOM w0.216: 163.69,160.75 163.42,160.59 arc(163.35,160.51) 163.32,160.41 163.32,158.77 arc(163.34,158.68) 163.38,158.61 165.46,156.53 arc(166.68,154.71) 167.11,152.57 167.11,150.21 167.11,143.71 167.11,139.9 arc(167.37,138.59) 168.11,137.47 171.92,133.67 arc(172.51,132.78) 172.72,131.73 172.72,114.76 arc(173.68,112.45) 175.98,111.49 176.53,111.49 arc(176.61,111.51) 176.67,111.55 arc(176.73,111.59) 176.81,111.61 C6G.2
SERDIN_P6: length 56.9
  BOTTOM w0.127: 164.66,164.21 arc(164.63,164.21) 164.6,164.22 164.52,164.23 arc(164.44,164.25) 164.38,164.3 arc(164.33,164.33) 164.29,164.34 163.22,164.34 arc(163.05,164.2) 163.15,164.02 163.23,163.98 arc(163.32,163.95) v1(163.41,163.95)
  BOTTOM w0.216: 164.66,164.21 166.18,164.21 arc(167.91,163.49) 168.63,161.76 168.63,153.19 168.66,153.16 168.66,152.31 168.63,152.28 168.63,141.12 arc(168.9,139.78) 169.65,138.65 173.46,134.84 arc(174.36,133.5) 174.68,131.91 174.68,117.77 arc(175.03,116.92) 175.87,116.57 176.53,116.57 arc(176.61,116.59) 176.67,116.63 arc(176.73,116.67) 176.81,116.69 C7G.2
SERDIN_P7: length 55.4
  TOP w0.216: C8G.2 v1(179.43,121.11)
  BOTTOM w0.127: v1(163.41,165.55) arc(163.32,165.55) 163.23,165.58 163.15,165.62 arc(163.05,165.8) 163.22,165.94 164.29,165.94 arc(164.33,165.93) 164.38,165.9 arc(164.44,165.85) 164.52,165.83 164.6,165.82 arc(164.63,165.81) 164.66,165.81
  BOTTOM w0.216: 164.66,165.81 166.65,165.81 arc(169.07,164.81) 170.08,162.38 170.08,141.18 arc(170.18,140.68) 170.46,140.26 174.91,135.81 arc(176.05,134.1) 176.45,132.08 176.45,130.27 arc(176.56,129.63) 176.83,129.04 arc(177.23,128.12) 177.37,127.13 177.37,122.25 arc(177.73,121.36) 178.63,120.99 arc(178.7,121.01) 178.76,121.05 arc(178.83,121.09) 178.9,121.11 v1(179.43,121.11)
SERDOUT_N0: length 36.5
  TOP w0.216: C1J.2 v1(188.52,162.23)
  BOTTOM w0.127: v1(162.61,175.95) arc(162.89,175.68) 163.27,175.58 164.3,175.58 arc(164.34,175.58) 164.38,175.61 arc(164.42,175.63) 164.45,175.64 164.59,175.67 arc(164.64,175.67) 164.7,175.68
  BOTTOM w0.216: 164.7,175.68 170.56,175.68 arc(172.22,175.38) 173.68,174.53 arc(175.14,173.68) 176.81,173.38 184.38,173.38 arc(187.41,172.12) 188.67,169.09 188.67,163.31 arc(188.67,163.28) 188.67,163.25 188.67,163.25 188.66,163.03 arc(188.64,162.95) 188.6,162.89 arc(188.55,162.83) 188.54,162.75 v1(188.52,162.23)
SERDOUT_N1: length 34
  BOTTOM w0.127: 164.7,174.08 arc(164.64,174.07) 164.59,174.07 164.45,174.04 arc(164.42,174.03) 164.38,174.01 arc(164.34,173.98) 164.3,173.98 163.27,173.98 arc(162.89,174.08) v1(162.61,174.35)
  BOTTOM w0.216: C2J.2 177.32,151.55 177.15,151.55 arc(176.16,151.96) 175.74,152.96 175.74,168.47 arc(175.73,168.58) 175.71,168.69 arc(173,172.57) 168.5,174.07 166.65,174.07 arc(166.57,174.07) 166.48,174.07 arc(166.44,174.08) 166.4,174.08 166.05,174.08 166.03,174.06 165.18,174.06 165.17,174.08 164.7,174.08
SERDOUT_N2: length 38.8
  BOTTOM w0.127: 164.7,172.48 arc(164.64,172.47) 164.59,172.47 164.45,172.44 arc(164.42,172.43) 164.38,172.41 arc(164.34,172.38) 164.3,172.38 163.27,172.38 arc(162.89,172.48) v1(162.61,172.75)
  BOTTOM w0.216: 164.7,172.48 166.47,172.48 arc(171.86,170.25) 174.09,164.86 174.09,152.24 arc(174.15,151.95) 174.31,151.71 174.97,151.05 arc(175.48,150.28) 175.66,149.38 175.66,144.78 arc(175.79,144.35) 176.15,144.08 arc(176.48,143.98) 176.83,143.95 176.86,143.95 arc(176.94,143.94) 177,143.9 arc(177.06,143.86) 177.14,143.84 C3J.2
SERDOUT_N3: length 44.7
  TOP w0.216: C4J.2 v1(181.05,140.11)
  BOTTOM w0.127: v1(162.61,171.15) arc(162.89,170.88) 163.27,170.78 164.3,170.78 arc(164.34,170.78) 164.38,170.81 arc(164.42,170.83) 164.45,170.84 164.59,170.87 arc(164.64,170.87) 164.7,170.88
  BOTTOM w0.216: 164.7,170.88 166.45,170.88 arc(170.74,169.1) 172.52,164.81 172.52,151.88 arc(172.58,151.57) 172.75,151.31 173.25,150.81 arc(173.52,150.41) 173.61,149.94 173.61,143.29 arc(173.63,143.07) 173.71,142.85 arc(174.04,142.28) 174.47,141.77 174.94,141.3 arc(175.14,141.12) 175.36,140.95 arc(176.21,140.51) 177.13,140.27 arc(177.44,140.23) 177.74,140.22 179.05,140.22 arc(179.06,140.22) 179.06,140.22 arc(179.13,140.22) 179.21,140.21 arc(179.45,140.15) 179.68,140.03 arc(180.38,139.83) v1(181.05,140.11)
SERDOUT_N4: length 54.1
  TOP w0.127: U1AA.H17 165.23,170.13 arc(165.41,170.01) 165.62,169.97 165.67,169.97 arc(165.71,169.96) 165.75,169.96 arc(165.8,169.96) 165.85,169.96 arc(165.91,169.96) 165.97,169.97 166.37,169.97 arc(166.38,169.97) 166.39,169.97 166.45,169.97
  TOP w0.216: 166.45,169.97 169.97,169.97 arc(174.45,168.12) 176.3,163.64 176.3,163.23 arc(176.67,161.4) 177.7,159.85 178.6,158.95 arc(179.3,157.89) 179.55,156.64 179.55,143.81 arc(179.51,143.51) 179.39,143.22 arc(179.2,142.8) 179.14,142.35 179.14,139.17 arc(179.85,137.44) 181.58,136.73 184.64,136.73 arc(185.2,136.62) 185.68,136.3 arc(186.36,135.85) 187.16,135.69 190.44,135.69 arc(190.48,135.67) 190.51,135.64 arc(190.58,135.6) 190.65,135.59 C5J.2
SERDOUT_N5: length 44.4
  TOP w0.127: 166.45,171.57 166.39,171.57 arc(166.38,171.57) 166.37,171.57 165.97,171.57 arc(165.91,171.56) 165.85,171.56 arc(165.81,171.56) 165.77,171.56 arc(165.7,171.56) 165.62,171.57 arc(165.41,171.61) 165.23,171.73 U1AA.F17
  TOP w0.216: 166.45,171.57 171.3,171.57 arc(175.99,169.63) 177.93,164.95 177.93,164.47 arc(178.34,162.38) 179.52,160.62 180.06,160.07 arc(181.15,158.45) 181.53,156.53 181.53,152.76 arc(181.67,152.08) 182.05,151.51 182.54,151.02 arc(183.04,150.69) 183.63,150.57 arc(185.24,149.9) 185.91,148.29 185.91,144.37 arc(186.34,143.35) 187.36,142.93 188.5,142.93 arc(188.58,142.9) C6J.2
SERDOUT_N6: length 44.1
  TOP w0.127: U1AA.D17 165.23,173.33 arc(165.41,173.21) 165.62,173.17 165.67,173.17 arc(165.71,173.16) 165.75,173.16 arc(165.8,173.16) 165.85,173.16 arc(165.91,173.16) 165.97,173.17 166.37,173.17 arc(166.38,173.17) 166.39,173.17 166.45,173.17
  TOP w0.216: 166.45,173.17 173.17,173.17 arc(177.7,171.3) 179.58,166.76 179.58,166.29 arc(180.14,163.47) 181.74,161.07 185.24,157.57 arc(185.25,157.56) 185.25,157.56 arc(185.38,157.33) 185.42,157.08 185.42,153.98 arc(185.58,153.18) 186.03,152.51 188.62,149.92 arc(189,149.36) 189.13,148.69 189.13,147.02 arc(189.46,146.21) 190.27,145.87 arc(190.63,145.84) C7J.2
SERDOUT_N7: length 35.9
  TOP w0.127: 166.45,174.77 166.44,174.77 165.97,174.77 arc(165.91,174.76) 165.85,174.76 arc(165.8,174.76) 165.75,174.76 arc(165.71,174.76) 165.67,174.77 165.62,174.77 arc(165.41,174.81) 165.23,174.93 U1AA.B17
  TOP w0.216: 166.45,174.77 177.1,174.77 arc(180.62,174.3) 183.89,172.9 arc(188.1,169.07) 190.47,163.9 arc(190.49,163.8) 190.5,163.69 190.5,159.12 arc(190.47,158.95) C8J.2
SERDOUT_P0: length 37.3
  TOP w0.216: C1I.2 v1(189.28,162.2)
  BOTTOM w0.127: v1(163.41,175.95) arc(163.32,175.95) 163.23,175.98 163.15,176.02 arc(163.05,176.2) 163.22,176.34 164.29,176.34 arc(164.33,176.33) 164.38,176.3 arc(164.45,176.25) 164.53,176.22 arc(164.6,176.21) 164.66,176.21
  BOTTOM w0.216: v1(189.28,162.2) 189.3,162.73 arc(189.29,162.8) 189.25,162.87 arc(189.21,162.93) 189.19,163.01 189.2,163.23 189.2,163.24 arc(189.2,163.27) 189.2,163.31 189.2,169.09 arc(187.79,172.5) 184.38,173.91 176.81,173.91 arc(175.33,174.18) 174.03,174.94 arc(172.41,175.88) 170.56,176.21 164.66,176.21
SERDOUT_P1: length 34
  BOTTOM w0.127: v1(163.41,174.35) arc(163.32,174.35) 163.23,174.38 163.15,174.41 arc(163.05,174.6) 163.22,174.74 164.29,174.74 arc(164.33,174.73) 164.38,174.7 arc(164.44,174.65) 164.52,174.63 164.6,174.62 arc(164.63,174.61) 164.66,174.61
  BOTTOM w0.216: C2I.2 177.32,152.08 177.15,152.08 arc(176.53,152.34) 176.28,152.96 176.28,168.47 arc(176.26,168.66) 176.22,168.84 arc(173.32,173) 168.5,174.6 166.65,174.6 arc(166.59,174.6) 166.53,174.6 arc(166.47,174.61) 166.4,174.61 165.82,174.61 165.81,174.6 165.4,174.6 165.39,174.61 164.66,174.61
SERDOUT_P2: length 38.8
  BOTTOM w0.127: v1(163.41,172.75) arc(163.32,172.75) 163.23,172.78 163.15,172.81 arc(163.05,173) 163.22,173.14 164.29,173.14 arc(164.33,173.13) 164.38,173.1 arc(164.44,173.05) 164.52,173.03 164.6,173.02 arc(164.63,173.01) 164.66,173.01
  BOTTOM w0.216: C3I.2 177.14,144.6 arc(177.06,144.59) 177,144.55 arc(176.94,144.5) 176.86,144.49 176.83,144.49 arc(176.58,144.51) 176.33,144.58 arc(176.23,144.65) 176.19,144.78 176.19,149.38 arc(176.16,149.8) 176.07,150.21 arc(175.79,150.86) 175.35,151.42 174.69,152.08 arc(174.64,152.15) 174.62,152.24 174.62,164.86 arc(172.24,170.62) 166.47,173.01 164.66,173.01
SERDOUT_P3: length 44.8
  TOP w0.216: C4I.2 v1(181.05,140.87)
  BOTTOM w0.127: 164.66,171.41 arc(164.63,171.41) 164.6,171.42 164.52,171.43 arc(164.44,171.45) 164.38,171.5 arc(164.33,171.53) 164.29,171.54 163.22,171.54 arc(163.05,171.4) 163.15,171.22 163.23,171.18 arc(163.32,171.15) v1(163.41,171.15)
  BOTTOM w0.216: 164.66,171.41 166.45,171.41 arc(171.12,169.48) 173.05,164.81 173.05,151.88 arc(173.07,151.77) 173.13,151.68 173.63,151.19 arc(174.01,150.62) 174.14,149.94 174.14,143.29 arc(174.15,143.18) 174.19,143.08 arc(174.48,142.59) 174.85,142.15 175.32,141.68 arc(175.48,141.53) 175.66,141.4 arc(176.4,141.01) 177.21,140.79 arc(177.48,140.76) 177.74,140.75 179.28,140.75 arc(179.33,140.75) 179.38,140.74 arc(179.44,140.73) 179.49,140.73 arc(179.69,140.8) 179.86,140.91 arc(179.9,140.94) 179.92,140.97 arc(179.96,141.01) 180.01,141.04 180.04,141.05 arc(180.14,141.08) 180.25,141.1 arc(180.44,141.1) 180.64,141.1 arc(180.87,141.04) v1(181.05,140.87)
SERDOUT_P4: length 54.1
  TOP w0.127: U1AA.H18 165.63,170.35 arc(165.52,170.4) 165.48,170.51 arc(165.55,170.67) 165.71,170.74 165.95,170.74 arc(166.08,170.71) 166.19,170.63 arc(166.28,170.57) 166.38,170.53 166.43,170.51 arc(166.44,170.51) 166.45,170.51
  TOP w0.216: C5I.2 190.65,136.35 arc(190.58,136.33) 190.51,136.29 arc(190.45,136.25) 190.37,136.23 190.37,136.22 187.16,136.22 arc(186.56,136.34) 186.05,136.68 arc(185.41,137.11) 184.64,137.26 181.58,137.26 arc(180.23,137.82) 179.67,139.17 179.67,142.35 arc(179.72,142.66) 179.84,142.94 arc(180.02,143.36) 180.09,143.81 180.09,156.64 arc(179.8,158.1) 178.97,159.33 178.08,160.22 arc(177.16,161.6) 176.83,163.23 176.83,163.64 arc(174.82,168.5) 169.97,170.51 166.45,170.51
SERDOUT_P5: length 44.5
  TOP w0.127: U1AA.F18 165.63,171.95 arc(165.52,172) 165.48,172.11 arc(165.55,172.27) 165.71,172.34 165.95,172.34 arc(166.08,172.31) 166.19,172.23 arc(166.28,172.17) 166.38,172.13 166.43,172.11 arc(166.44,172.11) 166.45,172.11
  TOP w0.216: 166.45,172.11 171.3,172.11 arc(176.36,170.01) 178.46,164.95 178.46,164.47 arc(178.83,162.59) 179.9,161 180.44,160.45 arc(181.64,158.65) 182.07,156.53 182.07,152.76 arc(182.16,152.29) 182.43,151.89 182.91,151.4 arc(183.24,151.18) 183.63,151.1 arc(185.62,150.28) 186.45,148.29 186.45,144.37 arc(186.71,143.73) 187.36,143.46 188.48,143.46 arc(188.57,143.5) C6I.2
SERDOUT_P6: length 44.1
  TOP w0.127: U1AA.D18 165.63,173.55 arc(165.52,173.6) 165.48,173.71 arc(165.55,173.87) 165.71,173.94 165.95,173.94 arc(166.08,173.91) 166.19,173.83 ; 166.16,173.86 166.19,173.83 ; 166.19,173.83 arc(166.28,173.77) 166.38,173.73 166.43,173.71 arc(166.44,173.71) 166.45,173.71
  TOP w0.216: 166.45,173.71 173.17,173.71 arc(178.08,171.67) 180.11,166.76 180.11,166.29 arc(180.63,163.67) 182.12,161.44 185.6,157.96 arc(185.86,157.55) 185.95,157.08 185.95,153.98 arc(186.07,153.39) 186.4,152.89 189,150.3 arc(189.49,149.56) 189.66,148.69 189.66,147.02 arc(189.84,146.58) 190.27,146.41 arc(190.62,146.43) C7I.2
SERDOUT_P7: length 36.8
  TOP w0.127: U1AA.B18 165.63,175.15 arc(165.52,175.2) 165.48,175.31 arc(165.55,175.47) 165.71,175.54 165.95,175.54 arc(166.08,175.51) 166.19,175.43 arc(166.28,175.37) 166.38,175.33 arc(166.44,175.31) 166.5,175.31
  TOP w0.216: 166.5,175.31 177.1,175.31 arc(180.76,174.81) 184.16,173.36 arc(188.53,169.39) 190.99,164.03 arc(191.02,163.86) 191.03,163.69 191.03,159.06 arc(191.06,158.93) C8I.2
SPI0_CSB: length 25.7
  TOP w0.241: v6(172.21,149.43) 171.9,149.12 171.77,149.12 171.74,149.09 U1FF.14
  L3_SIGNAL w0.178: v6(172.21,149.43) 172.97,150.19 172.97,152.6 174.11,153.75 177.96,153.75 178,153.71 178.26,153.71 178.3,153.75 180.76,153.75 186.22,148.29 186.69,148.29 188.05,146.92 v3(188.05,145.51)
SPI0_MISO: length 25.8
  TOP w0.241: v6(171.96,148.67) 171.87,148.59 U1FF.13
  L3_SIGNAL w0.178: v6(171.96,148.67) 174.88,148.67 175.51,148.03 176.4,148.03 176.78,148.41 176.78,151.21 177.54,151.97 181.23,151.97 182.62,150.57 182.62,150.19 186.18,146.64 186.18,145.37 186.69,144.86 187.43,144.86 v3(188.05,144.24)
SPI0_MOSI: length 26.2
  TOP w0.241: v6(172.21,147.78) 171.9,148.09 U1FF.12
  L3_SIGNAL w0.178: v3(182.97,146.78) 183.25,146.78 183.64,146.38 183.89,146.38 184.27,146.76 184.27,147.52 181.21,150.59 181.21,150.63 181.03,150.81 180.99,150.81 180.78,151.02 177.73,151.02 177.29,150.57 177.29,145.37 177.04,145.11 174.88,145.11 174.62,145.37 174.62,147.6 174.45,147.78 v6(172.21,147.78)
SPI0_SCLK: length 26.1
  TOP w0.241: U1FF.11 171.69,147.59 v6(172.21,147.07)
  L3_SIGNAL w0.178: v3(182.97,145.51) 182.1,145.51 182.09,145.49 180.72,145.49 180.08,146.13 180.08,146.89 180.59,147.4 181.48,147.4 181.73,147.65 181.73,149.3 181.23,149.81 178.43,149.81 177.92,149.3 177.92,145.11 177.54,144.73 174.37,144.73 173.99,145.11 173.99,146.56 173.48,147.07 v6(172.21,147.07)
SPI1_CSB: length 76.4
  TOP w0.241: v3(156.08,133.45) 152.88,133.45 148.98,129.55 148.98,126.03 147.63,124.68 146.27,124.68 144.6,123.01 142.24,123.01 139.95,120.73 139.95,110.31 141.35,108.92 141.35,106.54 141.26,106.46 141.26,106.04 141.35,105.96 141.35,105.23 142.72,103.86 v3(144.73,103.86) 145.26,103.38 U10FF.9
  L10_SIGNAL w0.178: v3(156.08,133.45) 157.63,133.45 162.3,138.13 175.9,138.13 177.43,139.65 183.47,139.65 v2(184.24,140.43)
  BOTTOM w0.241: TP12K.1 v3(144.73,103.86)
SPI1_SCLK: length 74.7
  TOP w0.241: U10FF.7 145.96,104.18 v6(145.72,104.42)
  L3_SIGNAL w0.178: v6(145.72,104.42) 147.7,102.44 149.22,102.44 150.41,103.63 v3(150.6,103.63) 150.49,103.74 150.49,104.34 149.98,104.85 149.98,107.34 150.49,107.85 150.49,115.65 150.11,116.03 150.11,119.33 149.86,119.58 149.86,121.45 150.15,121.74 150.15,122.51 149.94,122.72 149.94,122.97 v3(150.24,123.27)
  L10_SIGNAL w0.178: v3(150.24,123.27) 149.86,123.65 149.86,124.27 149.82,124.31 149.82,126.59 149.86,126.63 149.86,131.9 152.59,134.63 153.48,134.63 155.32,132.79 159.26,132.79 162.94,136.48 163.83,136.48 164.97,137.62 176.4,137.62 177.94,139.16 v2(182.97,139.16)
  BOTTOM w0.241: TP9K.1 v3(150.6,103.63)
SPI1_SDIO: length 73.6
  TOP w0.203: U10FF.8 145.57,103.78
  TOP w0.241: 145.57,103.78 v6(145.39,103.96)
  L3_SIGNAL w0.178: v3(150.49,124.03) 151.59,122.94 151.59,106.4 150.87,105.69 150.87,104.47 151.25,104.09 151.25,102.95 150.57,102.26 v3(150.57,101.85) 150.44,101.85 150.11,102.19 149.9,102.19 149.88,102.2 149.58,102.2 149.44,102.06 147.29,102.06 v6(145.39,103.96)
  L10_SIGNAL w0.178: v2(184.24,139.16) 183.64,138.55 183.64,137.87 181.48,135.71 170.05,135.71 168.02,133.68 165.28,133.68 162.81,131.22 154.85,131.22 150.1,126.47 150.1,124.42 v3(150.49,124.03)
  BOTTOM w0.241: TP3K.1 v3(150.57,101.85)
SPI_CSB: length 40.1
  TOP w0.241: v3(167,159.21) 167.64,158.57 167.64,156.03 166.82,155.22 165.63,155.22 165.38,155.46 165.38,156 165.01,156.38 163.81,156.38 163.57,156.14 163.57,155.41 163.95,155.02 163.95,153.62 163.45,153.11 163.45,152.22 163.63,152.04 163.63,152.04 163.9,151.77 163.9,151.77 163.95,151.72 165.29,151.72 166.69,150.31 166.69,149.33 166.94,149.09 U1FF.3
  L3_SIGNAL w0.178: v1(161.81,171.15) 162.19,170.77 164.72,170.77 164.97,170.51 165.73,170.51 165.99,170.77 166.62,170.77 168.02,169.37 168.02,165.17 167.65,164.8 167.65,163.27 168.27,162.65 168.27,162.12 167.7,161.55 167.7,160.8 167.76,160.74 167.76,157.98 167.59,157.8 167.27,157.8 167,158.07 v3(167,159.21)
SPI_SCLK: length 30.9
  TOP w0.241: v3(162.48,156.59) 162.35,156.46 162.35,153.16 161.8,152.6 161.8,149.94 161.22,149.37 R7.2
  L3_SIGNAL w0.178: v3(166.88,157.56) 166.37,158.07 166.37,159.38 166.66,159.67 166.66,159.87 167.23,160.44 167.23,168.51 166.88,168.86 166.88,169.24 166.11,170 162.15,170 v1(161.81,170.35)
  L10_SIGNAL w0.178: v3(162.48,156.59) 163.28,157.39 166.7,157.39 v3(166.88,157.56)
SPI_SDIO: length 35.5
  TOP w0.241: v3(162.43,152.07) 162.43,151.53 163.32,150.64 163.32,150 163,149.68 162.43,149.68 161.86,149.11 161.86,148.66 162.1,148.41 162.43,148.41 162.81,148.79 162.82,148.79 R6.2
  L3_SIGNAL w0.178: v3(167.26,154.89) 167.26,155.91 168.65,157.3 168.65,163.91 168.4,164.16 168.4,169.37 168.3,169.47 168.3,169.48 166.74,171.05 166.72,171.05 166.24,171.53 162.18,171.53 161.81,171.9 v1(161.81,171.95)
  L10_SIGNAL w0.178: v3(162.43,152.07) 162.43,153.14 162.91,153.62 165.99,153.62 v3(167.26,154.89)
STATUS_LED: length 12.7
  TOP w0.241: HMC_STATUS.C v3(141.43,102.87)
  BOTTOM w0.241: R2B.2 151.31,104.65 150.75,104.09 150.42,104.09 150.15,103.82 150.15,103.36 149.23,102.45 147.95,102.45 147.53,102.87 v3(141.43,102.87)
SYNC_IN: length 6.4
  TOP w0.241: R1E.2 140.72,112.78 R2E.1 141.74,111.47 v5(141.09,110.82)
  BOTTOM w0.241: U1B.6 141.41,111.13 v5(141.09,110.82) 140.24,109.97 R3B.1
SYNCIN_N0: length 44.7
  L10_SIGNAL w0.133: v2(188.05,148.05) 188.05,148.05 188.49,148.49 189.07,148.49 189.35,148.77 189.35,151.97 188.72,152.6 187.62,152.6 187.49,152.74 187.49,155.11 186.12,156.48 185.16,156.48 184.9,156.74 184.9,157.42 184.62,157.71 183.86,157.71 164.95,176.61 162.26,176.61 161.97,176.33 161.97,176.12 161.82,175.96 161.81,175.96 161.81,175.96 v1(161.81,175.95)
SYNCIN_N1: length 53.6
  L10_SIGNAL w0.133: v2(189.32,145.51) 189.32,145.88 189.46,146.01 190.89,146.01 191.39,146.51 191.39,157.13 190.83,157.68 186.41,157.68 180.38,163.71 180.38,164.5 169.62,175.26 167.83,175.26 165.71,177.38 161.7,177.38 161.16,176.84 161.16,176.11 v1(161.01,175.95)
SYNCIN_P0: length 44.4
  L10_SIGNAL w0.133: v2(188.05,149.32) 188.62,148.75 188.96,148.75 189.09,148.88 189.09,151.86 188.61,152.34 187.51,152.34 187.23,152.63 187.23,155 186.01,156.22 185.06,156.22 184.64,156.63 184.64,157.32 184.51,157.45 183.75,157.45 164.84,176.35 162.37,176.35 162.23,176.22 162.23,175.58 v1(161.81,175.15)
SYNCIN_P1: length 53.2
  L10_SIGNAL w0.133: v2(189.32,146.78) 189.32,146.4 189.46,146.27 190.78,146.27 191.13,146.62 191.13,157.02 190.72,157.42 186.3,157.42 180.12,163.6 180.12,164.39 169.51,175 167.72,175 165.61,177.12 161.81,177.12 161.42,176.73 161.42,176 161.41,175.99 161.41,175.56 v1(161.01,175.15)
SYNCOUT_N0: length 31.3
  L10_SIGNAL w0.133: v2(182.97,149.32) 182.97,149.69 182.84,149.82 182.46,149.82 182.19,150.09 182.19,157.15 181.91,157.43 181.16,157.43 177.3,161.29 162.26,161.29 161.81,161.74 v1(161.81,162.35)
SYNCOUT_N1: length 35.2
  L10_SIGNAL w0.133: v1(161.01,162.35) 161.01,161.14 161.75,160.4 175.73,160.4 179.97,156.16 180.6,156.16 180.97,155.8 180.97,147.93 181.63,147.26 184.15,147.26 184.24,147.17 v2(184.24,146.78)
SYNCOUT_P0: length 31.9
  L10_SIGNAL w0.133: v2(182.97,150.59) 182.97,150.21 182.84,150.08 182.57,150.08 182.45,150.2 182.45,157.26 182.02,157.69 181.27,157.69 177.41,161.55 162.36,161.55 162.09,161.83 162.09,162.11 162.21,162.23 162.21,162.74 v1(161.81,163.15)
SYNCOUT_P1: length 35.8
  L10_SIGNAL w0.133: v1(161.01,163.15) 161.01,163.12 161.38,162.75 161.38,162.06 161.27,161.95 161.27,161.25 161.86,160.66 175.84,160.66 180.08,156.42 180.71,156.42 181.23,155.91 181.23,148.03 181.73,147.52 184.15,147.52 184.24,147.62 v2(184.24,148.05)
SYSREF2_N: length 97
  L10_SIGNAL w0.133: v2(182.97,153.13) 183.47,153.62 184.41,153.62 187.32,150.71 187.32,143.97 187.83,143.46 190.99,143.46 191.13,143.33 191.13,126.54 183.56,118.97 arc(183.47,118.83) 183.44,118.67 183.44,115.83 arc(183.42,115.77) 183.39,115.71 177.23,109.56 169.72,109.56 arc(169.55,109.53) 169.41,109.43 161.48,101.51 arc(161.43,101.47) 161.36,101.46 152.07,101.46 arc(152,101.47) 151.95,101.51 151.06,102.4 arc(151,102.43) 150.94,102.45 146.93,102.45 146.56,102.82 146.56,105.92 arc(146.4,106.28) 146.04,106.44 145.5,106.44 145.22,106.15 145.22,105.71 144.96,105.46 v2(144.96,105.04)
  BOTTOM w0.241: C40B.2 v2(144.96,105.04)
SYSREF2_P: length 97.5
  L10_SIGNAL w0.133: v2(145.73,105.04) 145.73,105.46 145.48,105.71 145.48,106.04 145.61,106.17 146.04,106.17 arc(146.22,106.1) 146.3,105.92 146.3,102.71 146.82,102.19 150.9,102.19 151.76,101.32 arc(151.9,101.23) 152.07,101.2 161.36,101.2 arc(161.53,101.23) 161.67,101.32 169.59,109.25 arc(169.65,109.29) 169.71,109.3 177.34,109.3 183.57,115.53 arc(183.66,115.67) 183.7,115.83 183.7,118.67 arc(183.71,118.74) 183.75,118.79 191.39,126.43 191.39,143.44 191.1,143.72 187.94,143.72 187.58,144.08 187.58,150.82 184.52,153.88 183.49,153.88 v2(182.97,154.4)
  BOTTOM w0.241: C39B.2 v2(145.73,105.04)
